
    const byte PROGMEM frames[][288] = {
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   1, 128,   0,   0,   0,   0,   1, 128,   0,   0,   0,   0,   3,
     192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   7, 224,   0,   0,
       0,   0,   7, 224,   0,   0,   0,   0,  15, 240,   0,   0,   0,   0,  31,
     248,   0,   0,   0,   0,  31, 248,   0,   0,   0,   0,  63, 252,   0,   0,
       0,   0,  63, 252,   0,   0,   0,   0, 127, 254,   0,   0,   0,   0, 127,
     254,   0,   0,   0,   0, 255, 255,   0,   0,   0,   0,   3, 192,   0,   0,
       0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3,
     192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,
       0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3,
     192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,
       0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3,
     192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,
       0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3,
     192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,
       0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   8,   0,   0,   0,
       0,   0,   8,   0,   0,   0,   0,   0,  12,   0,   0,   0,   0,   0,  30,
       0,   0,   0,   0,   0,  31,   0,   0,   0,   0,   0,  31, 128,   0,   0,
       0,   0,  31, 128,   0,   0,   0,   0,  63, 192,   0,   0,   0,   0,  63,
     224,   0,   0,   0,   0,  63, 240,   0,   0,   0,   0, 127, 248,   0,   0,
       0,   0, 127, 248,   0,   0,   0,   0, 127, 252,   0,   0,   0,   0, 255,
     254,   0,   0,   0,   0, 255, 192,   0,   0,   0,   0, 251, 128,   0,   0,
       0,   0,   3, 128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   3,
     128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   1, 192,   0,   0,
       0,   0,   1, 192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1,
     192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1, 192,   0,   0,
       0,   0,   0, 224,   0,   0,   0,   0,   0, 224,   0,   0,   0,   0,   0,
     224,   0,   0,   0,   0,   0, 224,   0,   0,   0,   0,   0, 224,   0,   0,
       0,   0,   0, 112,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0,
     112,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0, 112,   0,   0,
       0,   0,   0, 112,   0,   0,   0,   0,   0,  48,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,  96,   0,   0,   0,   0,   0, 112,
       0,   0,   0,   0,   0, 120,   0,   0,   0,   0,   0, 124,   0,   0,   0,
       0,   0, 254,   0,   0,   0,   0,   0, 255,   0,   0,   0,   0,   0, 255,
     128,   0,   0,   0,   0, 255, 192,   0,   0,   0,   0, 255, 240,   0,   0,
       0,   0, 255, 248,   0,   0,   0,   0, 255, 252,   0,   0,   0,   1, 255,
     224,   0,   0,   0,   1, 255,   0,   0,   0,   0,   1, 255,   0,   0,   0,
       0,   1, 231,   0,   0,   0,   0,   1,   7, 128,   0,   0,   0,   0,   3,
     128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   1, 192,   0,   0,
       0,   0,   1, 192,   0,   0,   0,   0,   1, 224,   0,   0,   0,   0,   0,
     224,   0,   0,   0,   0,   0, 224,   0,   0,   0,   0,   0, 240,   0,   0,
       0,   0,   0, 112,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0,
     120,   0,   0,   0,   0,   0,  56,   0,   0,   0,   0,   0,  56,   0,   0,
       0,   0,   0,  28,   0,   0,   0,   0,   0,  28,   0,   0,   0,   0,   0,
      30,   0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  14,   0,   0,
       0,   0,   0,  14,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   2,   0,
       0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   3, 224,   0,   0,   0,
       0,   3, 240,   0,   0,   0,   0,   3, 252,   0,   0,   0,   0,   3, 254,
       0,   0,   0,   0,   3, 255, 128,   0,   0,   0,   3, 255, 224,   0,   0,
       0,   3, 255, 240,   0,   0,   0,   3, 255, 224,   0,   0,   0,   3, 255,
     128,   0,   0,   0,   3, 255,   0,   0,   0,   0,   3, 254,   0,   0,   0,
       0,   3, 255,   0,   0,   0,   0,   3, 199,   0,   0,   0,   0,   1, 135,
     128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   1, 192,   0,   0,
       0,   0,   1, 224,   0,   0,   0,   0,   0, 224,   0,   0,   0,   0,   0,
     240,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0, 120,   0,   0,
       0,   0,   0,  56,   0,   0,   0,   0,   0,  28,   0,   0,   0,   0,   0,
      30,   0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  15,   0,   0,
       0,   0,   0,   7,   0,   0,   0,   0,   0,   7, 128,   0,   0,   0,   0,
       3, 192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1, 128,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,  24,   0,   0,   0,   0,
       0,  15,   0,   0,   0,   0,   0,  15, 192,   0,   0,   0,   0,  15, 248,
       0,   0,   0,   0,  15, 254,   0,   0,   0,   0,  15, 255, 192,   0,   0,
       0,   7, 255, 192,   0,   0,   0,   7, 255, 128,   0,   0,   0,   7, 255,
       0,   0,   0,   0,   7, 254,   0,   0,   0,   0,   7, 252,   0,   0,   0,
       0,   3, 254,   0,   0,   0,   0,   3, 239,   0,   0,   0,   0,   3, 199,
     128,   0,   0,   0,   3, 131, 192,   0,   0,   0,   3,   3, 192,   0,   0,
       0,   0,   1, 224,   0,   0,   0,   0,   0, 240,   0,   0,   0,   0,   0,
     120,   0,   0,   0,   0,   0,  60,   0,   0,   0,   0,   0,  30,   0,   0,
       0,   0,   0,  30,   0,   0,   0,   0,   0,  15,   0,   0,   0,   0,   0,
       7, 128,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   1, 224,   0,
       0,   0,   0,   0, 240,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,
       0, 112,   0,   0,   0,   0,   0,  32,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,  64,   0,   0,   0,   0,   0, 126,   0,
       0,   0,   0,   0,  63, 240,   0,   0,   0,   0,  63, 255, 128,   0,   0,
       0,  63, 255, 128,   0,   0,   0,  31, 255,   0,   0,   0,   0,  31, 254,
       0,   0,   0,   0,  15, 252,   0,   0,   0,   0,  15, 248,   0,   0,   0,
       0,  15, 252,   0,   0,   0,   0,   7, 254,   0,   0,   0,   0,   7, 239,
     128,   0,   0,   0,   3, 199, 192,   0,   0,   0,   3, 131, 224,   0,   0,
       0,   3,   1, 240,   0,   0,   0,   0,   0, 120,   0,   0,   0,   0,   0,
      62,   0,   0,   0,   0,   0,  31,   0,   0,   0,   0,   0,  15, 128,   0,
       0,   0,   0,   7, 192,   0,   0,   0,   0,   1, 224,   0,   0,   0,   0,
       0, 240,   0,   0,   0,   0,   0, 124,   0,   0,   0,   0,   0,  62,   0,
       0,   0,   0,   0,  28,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   1, 255, 252,   0,   0,   0,
       0, 255, 254,   0,   0,   0,   0, 255, 254,   0,   0,   0,   0, 127, 252,
       0,   0,   0,   0, 127, 248,   0,   0,   0,   0,  63, 248,   0,   0,   0,
       0,  31, 248,   0,   0,   0,   0,  31, 254,   0,   0,   0,   0,  15, 255,
       0,   0,   0,   0,   7, 239, 192,   0,   0,   0,   7, 195, 240,   0,   0,
       0,   3, 128, 252,   0,   0,   0,   3, 128, 126,   0,   0,   0,   1,   0,
      31, 128,   0,   0,   0,   0,   7, 224,   0,   0,   0,   0,   1, 248,   0,
       0,   0,   0,   0, 252,   0,   0,   0,   0,   0,  63,   0,   0,   0,   0,
       0,  15,   0,   0,   0,   0,   0,   6,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0, 124,   0,   0,   0,   0,  63, 248,   0,   0,   0,   3, 255, 248,
       0,   0,   0,   3, 255, 248,   0,   0,   0,   1, 255, 240,   0,   0,   0,
       0, 255, 240,   0,   0,   0,   0, 127, 252,   0,   0,   0,   0,  63, 255,
       0,   0,   0,   0,  31, 255, 224,   0,   0,   0,  15, 199, 252,   0,   0,
       0,   7, 192, 255, 128,   0,   0,   3, 192,  63, 224,   0,   0,   3, 128,
       7, 252,   0,   0,   1, 128,   0, 255, 128,   0,   0, 128,   0,  31, 128,
       0,   0,   0,   0,   7, 128,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   3, 240,
       0,   0,   0,   0,  31, 240,   0,   0,   0,   1, 255, 240,   0,   0,   0,
      15, 255, 240,   0,   0,   0,   3, 255, 224,   0,   0,   0,   1, 255, 255,
       0,   0,   0,   0, 255, 255, 252,   0,   0,   0, 127, 255, 255, 224,   0,
       0,  31, 224, 255, 255, 128,   0,  15, 192,   3, 255, 192,   0,   7, 192,
       0,  31, 192,   0,   3, 192,   0,   0,   0,   0,   0, 192,   0,   0,   0,
       0,   0,  64,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,  32,   0,   0,   0,   0,   0, 224,
       0,   0,   0,   0,   3, 224,   0,   0,   0,   0,  15, 224,   0,   0,   0,
       0,  31, 224,   0,   0,   0,   0, 127, 224,   0,   0,   0,   1, 255, 255,
     255, 255, 192,   7, 255, 255, 255, 255, 192,   7, 255, 255, 255, 255, 192,
       1, 255, 255, 255, 255, 192,   0, 127, 224,   0,   0,   0,   0,  31, 224,
       0,   0,   0,   0,  15, 224,   0,   0,   0,   0,   3, 224,   0,   0,   0,
       0,   0, 224,   0,   0,   0,   0,   0,  32,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,  64,
       0,   0,   0,   0,   0, 192,   0,   0,   0,   0,   3, 192,   0,   0,   0,
       0,   7, 192,   0,  31, 192,   0,  15, 192,   3, 255, 192,   0,  31, 224,
     255, 255, 128,   0, 127, 255, 255, 224,   0,   0, 255, 255, 252,   0,   0,
       1, 255, 255,   0,   0,   0,   3, 255, 224,   0,   0,   0,  15, 255, 240,
       0,   0,   0,   1, 255, 240,   0,   0,   0,   0,  31, 240,   0,   0,   0,
       0,   3, 240,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   7, 128,   0,   0, 128,   0,  31, 128,   0,   1, 128,   0, 255, 128,
       0,   3, 128,   7, 252,   0,   0,   3, 192,  63, 224,   0,   0,   7, 192,
     255, 128,   0,   0,  15, 199, 252,   0,   0,   0,  31, 255, 224,   0,   0,
       0,  63, 255,   0,   0,   0,   0, 127, 252,   0,   0,   0,   0, 255, 240,
       0,   0,   0,   1, 255, 240,   0,   0,   0,   3, 255, 248,   0,   0,   0,
       3, 255, 248,   0,   0,   0,   0,  63, 248,   0,   0,   0,   0,   0, 124,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   6,   0,
       0,   0,   0,   0,  15,   0,   0,   0,   0,   0,  63,   0,   0,   0,   0,
       0, 252,   0,   0,   0,   0,   1, 248,   0,   0,   0,   0,   7, 224,   0,
       0,   1,   0,  31, 128,   0,   0,   3, 128, 126,   0,   0,   0,   3, 128,
     252,   0,   0,   0,   7, 195, 240,   0,   0,   0,   7, 239, 192,   0,   0,
       0,  15, 255,   0,   0,   0,   0,  31, 254,   0,   0,   0,   0,  31, 248,
       0,   0,   0,   0,  63, 248,   0,   0,   0,   0, 127, 248,   0,   0,   0,
       0, 127, 252,   0,   0,   0,   0, 255, 254,   0,   0,   0,   0, 255, 254,
       0,   0,   0,   1, 255, 252,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,  28,   0,   0,   0,   0,   0,  62,   0,   0,   0,   0,   0, 124,   0,
       0,   0,   0,   0, 240,   0,   0,   0,   0,   1, 224,   0,   0,   0,   0,
       7, 192,   0,   0,   0,   0,  15, 128,   0,   0,   0,   0,  31,   0,   0,
       0,   0,   0,  62,   0,   0,   0,   0,   0, 120,   0,   0,   0,   3,   1,
     240,   0,   0,   0,   3, 131, 224,   0,   0,   0,   3, 199, 192,   0,   0,
       0,   7, 239, 128,   0,   0,   0,   7, 254,   0,   0,   0,   0,  15, 252,
       0,   0,   0,   0,  15, 248,   0,   0,   0,   0,  15, 252,   0,   0,   0,
       0,  31, 254,   0,   0,   0,   0,  31, 255,   0,   0,   0,   0,  63, 255,
     128,   0,   0,   0,  63, 255, 128,   0,   0,   0,  63, 240,   0,   0,   0,
       0, 126,   0,   0,   0,   0,   0,  64,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,  32,   0,
       0,   0,   0,   0, 112,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,
       0, 240,   0,   0,   0,   0,   1, 224,   0,   0,   0,   0,   3, 192,   0,
       0,   0,   0,   7, 128,   0,   0,   0,   0,  15,   0,   0,   0,   0,   0,
      30,   0,   0,   0,   0,   0,  30,   0,   0,   0,   0,   0,  60,   0,   0,
       0,   0,   0, 120,   0,   0,   0,   0,   0, 240,   0,   0,   0,   0,   1,
     224,   0,   0,   0,   3,   3, 192,   0,   0,   0,   3, 131, 192,   0,   0,
       0,   3, 199, 128,   0,   0,   0,   3, 239,   0,   0,   0,   0,   3, 254,
       0,   0,   0,   0,   7, 252,   0,   0,   0,   0,   7, 254,   0,   0,   0,
       0,   7, 255,   0,   0,   0,   0,   7, 255, 128,   0,   0,   0,   7, 255,
     192,   0,   0,   0,  15, 255, 192,   0,   0,   0,  15, 254,   0,   0,   0,
       0,  15, 248,   0,   0,   0,   0,  15, 192,   0,   0,   0,   0,  15,   0,
       0,   0,   0,   0,  24,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   1, 128,   0,   0,   0,   0,   1, 192,   0,
       0,   0,   0,   3, 192,   0,   0,   0,   0,   7, 128,   0,   0,   0,   0,
       7,   0,   0,   0,   0,   0,  15,   0,   0,   0,   0,   0,  14,   0,   0,
       0,   0,   0,  30,   0,   0,   0,   0,   0,  28,   0,   0,   0,   0,   0,
      56,   0,   0,   0,   0,   0, 120,   0,   0,   0,   0,   0, 112,   0,   0,
       0,   0,   0, 240,   0,   0,   0,   0,   0, 224,   0,   0,   0,   0,   1,
     224,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   3, 128,   0,   0,
       0,   1, 135, 128,   0,   0,   0,   3, 199,   0,   0,   0,   0,   3, 255,
       0,   0,   0,   0,   3, 254,   0,   0,   0,   0,   3, 255,   0,   0,   0,
       0,   3, 255, 128,   0,   0,   0,   3, 255, 224,   0,   0,   0,   3, 255,
     240,   0,   0,   0,   3, 255, 224,   0,   0,   0,   3, 255, 128,   0,   0,
       0,   3, 254,   0,   0,   0,   0,   3, 252,   0,   0,   0,   0,   3, 240,
       0,   0,   0,   0,   3, 224,   0,   0,   0,   0,   3, 128,   0,   0,   0,
       0,   2,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
      14,   0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  14,   0,   0,
       0,   0,   0,  30,   0,   0,   0,   0,   0,  28,   0,   0,   0,   0,   0,
      28,   0,   0,   0,   0,   0,  56,   0,   0,   0,   0,   0,  56,   0,   0,
       0,   0,   0, 120,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0,
     112,   0,   0,   0,   0,   0, 240,   0,   0,   0,   0,   0, 224,   0,   0,
       0,   0,   0, 224,   0,   0,   0,   0,   1, 224,   0,   0,   0,   0,   1,
     192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   3, 128,   0,   0,
       0,   0,   3, 128,   0,   0,   0,   1,   7, 128,   0,   0,   0,   1, 231,
       0,   0,   0,   0,   1, 255,   0,   0,   0,   0,   1, 255,   0,   0,   0,
       0,   1, 255, 224,   0,   0,   0,   0, 255, 252,   0,   0,   0,   0, 255,
     248,   0,   0,   0,   0, 255, 240,   0,   0,   0,   0, 255, 192,   0,   0,
       0,   0, 255, 128,   0,   0,   0,   0, 255,   0,   0,   0,   0,   0, 254,
       0,   0,   0,   0,   0, 124,   0,   0,   0,   0,   0, 120,   0,   0,   0,
       0,   0, 112,   0,   0,   0,   0,   0,  96,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,  48,   0,   0,   0,   0,   0,
     112,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0, 112,   0,   0,
       0,   0,   0, 112,   0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0,
     112,   0,   0,   0,   0,   0, 224,   0,   0,   0,   0,   0, 224,   0,   0,
       0,   0,   0, 224,   0,   0,   0,   0,   0, 224,   0,   0,   0,   0,   0,
     224,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1, 192,   0,   0,
       0,   0,   1, 192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1,
     192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   3, 128,   0,   0,
       0,   0,   3, 128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   3,
     128,   0,   0,   0,   0, 251, 128,   0,   0,   0,   0, 255, 192,   0,   0,
       0,   0, 255, 254,   0,   0,   0,   0, 127, 252,   0,   0,   0,   0, 127,
     248,   0,   0,   0,   0, 127, 248,   0,   0,   0,   0,  63, 240,   0,   0,
       0,   0,  63, 224,   0,   0,   0,   0,  63, 192,   0,   0,   0,   0,  31,
     128,   0,   0,   0,   0,  31, 128,   0,   0,   0,   0,  31,   0,   0,   0,
       0,   0,  30,   0,   0,   0,   0,   0,  12,   0,   0,   0,   0,   0,   8,
       0,   0,   0,   0,   0,   8,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1,
     192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1, 192,   0,   0,
       0,   0,   1, 192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1,
     192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1, 192,   0,   0,
       0,   0,   1, 192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   3,
     192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,
       0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3,
     192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,
       0,   0,   3, 192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3,
     192,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0, 255, 255,   0,   0,
       0,   0, 127, 254,   0,   0,   0,   0, 127, 254,   0,   0,   0,   0,  63,
     252,   0,   0,   0,   0,  63, 252,   0,   0,   0,   0,  31, 248,   0,   0,
       0,   0,  31, 248,   0,   0,   0,   0,  15, 240,   0,   0,   0,   0,   7,
     224,   0,   0,   0,   0,   7, 224,   0,   0,   0,   0,   3, 192,   0,   0,
       0,   0,   3, 192,   0,   0,   0,   0,   1, 128,   0,   0,   0,   0,   1,
     128,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,  12,   0,   0,   0,   0,   0,  14,
       0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  14,   0,   0,   0,
       0,   0,  14,   0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  14,
       0,   0,   0,   0,   0,   7,   0,   0,   0,   0,   0,   7,   0,   0,   0,
       0,   0,   7,   0,   0,   0,   0,   0,   7,   0,   0,   0,   0,   0,   7,
       0,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   3, 128,   0,   0,
       0,   0,   3, 128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   3,
     128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   1, 192,   0,   0,
       0,   0,   1, 192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1,
     192,   0,   0,   0,   0,   1, 223,   0,   0,   0,   0,   3, 255,   0,   0,
       0,   0, 127, 255,   0,   0,   0,   0,  63, 254,   0,   0,   0,   0,  31,
     254,   0,   0,   0,   0,  31, 254,   0,   0,   0,   0,  15, 252,   0,   0,
       0,   0,   7, 252,   0,   0,   0,   0,   3, 252,   0,   0,   0,   0,   1,
     248,   0,   0,   0,   0,   1, 248,   0,   0,   0,   0,   0, 248,   0,   0,
       0,   0,   0, 120,   0,   0,   0,   0,   0,  48,   0,   0,   0,   0,   0,
      16,   0,   0,   0,   0,   0,  16,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0, 112,
       0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0, 112,   0,   0,   0,
       0,   0, 120,   0,   0,   0,   0,   0,  56,   0,   0,   0,   0,   0,  56,
       0,   0,   0,   0,   0,  28,   0,   0,   0,   0,   0,  28,   0,   0,   0,
       0,   0,  30,   0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  14,
       0,   0,   0,   0,   0,  15,   0,   0,   0,   0,   0,   7,   0,   0,   0,
       0,   0,   7,   0,   0,   0,   0,   0,   7, 128,   0,   0,   0,   0,   3,
     128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   1, 192,   0,   0,
       0,   0,   1, 192,   0,   0,   0,   0,   1, 224, 128,   0,   0,   0,   0,
     231, 128,   0,   0,   0,   0, 255, 128,   0,   0,   0,   0, 255, 128,   0,
       0,   0,   7, 255, 128,   0,   0,   0,  63, 255,   0,   0,   0,   0,  31,
     255,   0,   0,   0,   0,  15, 255,   0,   0,   0,   0,   3, 255,   0,   0,
       0,   0,   1, 255,   0,   0,   0,   0,   0, 255,   0,   0,   0,   0,   0,
     127,   0,   0,   0,   0,   0,  62,   0,   0,   0,   0,   0,  30,   0,   0,
       0,   0,   0,  14,   0,   0,   0,   0,   0,   6,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   1, 128,   0,   0,   0,   0,   3, 128,   0,   0,   0,
       0,   3, 192,   0,   0,   0,   0,   1, 224,   0,   0,   0,   0,   0, 224,
       0,   0,   0,   0,   0, 240,   0,   0,   0,   0,   0, 112,   0,   0,   0,
       0,   0, 120,   0,   0,   0,   0,   0,  56,   0,   0,   0,   0,   0,  28,
       0,   0,   0,   0,   0,  30,   0,   0,   0,   0,   0,  14,   0,   0,   0,
       0,   0,  15,   0,   0,   0,   0,   0,   7,   0,   0,   0,   0,   0,   7,
     128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   1, 192,   0,   0,
       0,   0,   1, 225, 128,   0,   0,   0,   0, 227, 192,   0,   0,   0,   0,
     255, 192,   0,   0,   0,   0, 127, 192,   0,   0,   0,   0, 255, 192,   0,
       0,   0,   1, 255, 192,   0,   0,   0,   7, 255, 192,   0,   0,   0,  15,
     255, 192,   0,   0,   0,   7, 255, 192,   0,   0,   0,   1, 255, 192,   0,
       0,   0,   0, 127, 192,   0,   0,   0,   0,  63, 192,   0,   0,   0,   0,
      15, 192,   0,   0,   0,   0,   7, 192,   0,   0,   0,   0,   1, 192,   0,
       0,   0,   0,   0,  64,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   4,   0,   0,   0,   0,
       0,  14,   0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  15,   0,
       0,   0,   0,   0,   7, 128,   0,   0,   0,   0,   3, 192,   0,   0,   0,
       0,   1, 224,   0,   0,   0,   0,   0, 240,   0,   0,   0,   0,   0, 120,
       0,   0,   0,   0,   0, 120,   0,   0,   0,   0,   0,  60,   0,   0,   0,
       0,   0,  30,   0,   0,   0,   0,   0,  15,   0,   0,   0,   0,   0,   7,
     128,   0,   0,   0,   0,   3, 192, 192,   0,   0,   0,   3, 193, 192,   0,
       0,   0,   1, 227, 192,   0,   0,   0,   0, 247, 192,   0,   0,   0,   0,
     127, 192,   0,   0,   0,   0,  63, 224,   0,   0,   0,   0, 127, 224,   0,
       0,   0,   0, 255, 224,   0,   0,   0,   1, 255, 224,   0,   0,   0,   3,
     255, 224,   0,   0,   0,   3, 255, 240,   0,   0,   0,   0, 127, 240,   0,
       0,   0,   0,  31, 240,   0,   0,   0,   0,   3, 240,   0,   0,   0,   0,
       0, 240,   0,   0,   0,   0,   0,  24,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,  56,   0,
       0,   0,   0,   0, 124,   0,   0,   0,   0,   0,  62,   0,   0,   0,   0,
       0,  15,   0,   0,   0,   0,   0,   7, 128,   0,   0,   0,   0,   3, 224,
       0,   0,   0,   0,   1, 240,   0,   0,   0,   0,   0, 248,   0,   0,   0,
       0,   0, 124,   0,   0,   0,   0,   0,  30,   0,   0,   0,   0,   0,  15,
     128, 192,   0,   0,   0,   7, 193, 192,   0,   0,   0,   3, 227, 192,   0,
       0,   0,   1, 247, 224,   0,   0,   0,   0, 127, 224,   0,   0,   0,   0,
      63, 240,   0,   0,   0,   0,  31, 240,   0,   0,   0,   0,  63, 240,   0,
       0,   0,   0, 127, 248,   0,   0,   0,   0, 255, 248,   0,   0,   0,   1,
     255, 252,   0,   0,   0,   1, 255, 252,   0,   0,   0,   0,  15, 252,   0,
       0,   0,   0,   0, 126,   0,   0,   0,   0,   0,   2,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,  96,   0,   0,   0,   0,
       0, 240,   0,   0,   0,   0,   0, 252,   0,   0,   0,   0,   0,  63,   0,
       0,   0,   0,   0,  31, 128,   0,   0,   0,   0,   7, 224,   0,   0,   0,
       0,   1, 248,   0, 128,   0,   0,   0, 126,   1, 192,   0,   0,   0,  63,
       1, 192,   0,   0,   0,  15, 195, 224,   0,   0,   0,   3, 247, 224,   0,
       0,   0,   0, 255, 240,   0,   0,   0,   0, 127, 248,   0,   0,   0,   0,
      31, 248,   0,   0,   0,   0,  31, 252,   0,   0,   0,   0,  31, 254,   0,
       0,   0,   0,  63, 254,   0,   0,   0,   0, 127, 255,   0,   0,   0,   0,
     127, 255,   0,   0,   0,   0,  63, 255, 128,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   1, 224,   0,
       0,   0,   0,   1, 248,   0,   1,   0,   0,   1, 255,   0,   1, 128,   0,
       0,  63, 224,   1, 192,   0,   0,   7, 252,   3, 192,   0,   0,   1, 255,
       3, 224,   0,   0,   0,  63, 227, 240,   0,   0,   0,   7, 255, 248,   0,
       0,   0,   0, 255, 252,   0,   0,   0,   0,  63, 254,   0,   0,   0,   0,
      15, 255,   0,   0,   0,   0,  15, 255, 128,   0,   0,   0,  31, 255, 192,
       0,   0,   0,  31, 255, 192,   0,   0,   0,  31, 252,   0,   0,   0,   0,
      62,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       2,   0,   0,   0,   0,   0,   3,   0,   0,   0,   0,   0,   3, 192,   0,
       3, 248,   0,   3, 224,   0,   3, 255, 192,   3, 240,   0,   1, 255, 255,
       7, 248,   0,   0,   7, 255, 255, 254,   0,   0,   0,  63, 255, 255,   0,
       0,   0,   0, 255, 255, 128,   0,   0,   0,   7, 255, 192,   0,   0,   0,
      15, 255, 240,   0,   0,   0,  15, 255, 128,   0,   0,   0,  15, 248,   0,
       0,   0,   0,  15, 192,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   4,   0,   0,   0,   0,   0,
       7,   0,   0,   0,   0,   0,   7, 192,   0,   0,   0,   0,   7, 240,   0,
       0,   0,   0,   7, 248,   0,   0,   0,   0,   7, 254,   0,   3, 255, 255,
     255, 255, 128,   3, 255, 255, 255, 255, 224,   3, 255, 255, 255, 255, 224,
       0,   0,   0,   7, 255, 128,   0,   0,   0,   7, 254,   0,   0,   0,   0,
       7, 248,   0,   0,   0,   0,   7, 240,   0,   0,   0,   0,   7, 192,   0,
       0,   0,   0,   7,   0,   0,   0,   0,   0,   4,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,
      15, 192,   0,   0,   0,   0,  15, 248,   0,   0,   0,   0,  15, 255, 128,
       0,   0,   0,  15, 255, 240,   0,   0,   0,   7, 255, 192,   0,   0,   0,
     255, 255, 128,   0,   0,  63, 255, 255,   0,   0,   7, 255, 255, 254,   0,
       1, 255, 255,   7, 248,   0,   3, 255, 192,   3, 240,   0,   3, 248,   0,
       3, 224,   0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   3,   0,   0,
       0,   0,   0,   2,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,  62,   0,   0,   0,   0,   0,  31, 252,   0,   0,   0,   0,
      31, 255, 192,   0,   0,   0,  31, 255, 192,   0,   0,   0,  15, 255, 128,
       0,   0,   0,  15, 255,   0,   0,   0,   0,  63, 254,   0,   0,   0,   0,
     255, 252,   0,   0,   0,   7, 255, 248,   0,   0,   0,  63, 227, 240,   0,
       0,   1, 255,   3, 224,   0,   0,   7, 252,   3, 192,   0,   0,  63, 224,
       1, 192,   0,   1, 255,   0,   1, 128,   0,   1, 248,   0,   1,   0,   0,
       1, 224,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,  63, 255, 128,
       0,   0,   0, 127, 255,   0,   0,   0,   0, 127, 255,   0,   0,   0,   0,
      63, 254,   0,   0,   0,   0,  31, 254,   0,   0,   0,   0,  31, 252,   0,
       0,   0,   0,  31, 248,   0,   0,   0,   0, 127, 248,   0,   0,   0,   0,
     255, 240,   0,   0,   0,   3, 247, 224,   0,   0,   0,  15, 195, 224,   0,
       0,   0,  63,   1, 192,   0,   0,   0, 126,   1, 192,   0,   0,   1, 248,
       0, 128,   0,   0,   7, 224,   0,   0,   0,   0,  31, 128,   0,   0,   0,
       0,  63,   0,   0,   0,   0,   0, 252,   0,   0,   0,   0,   0, 240,   0,
       0,   0,   0,   0,  96,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   2,   0,   0,   0,   0,
       0, 126,   0,   0,   0,   0,  15, 252,   0,   0,   0,   1, 255, 252,   0,
       0,   0,   1, 255, 252,   0,   0,   0,   0, 255, 248,   0,   0,   0,   0,
     127, 248,   0,   0,   0,   0,  63, 240,   0,   0,   0,   0,  31, 240,   0,
       0,   0,   0,  63, 240,   0,   0,   0,   0, 127, 224,   0,   0,   0,   1,
     247, 224,   0,   0,   0,   3, 227, 192,   0,   0,   0,   7, 193, 192,   0,
       0,   0,  15, 128, 192,   0,   0,   0,  30,   0,   0,   0,   0,   0, 124,
       0,   0,   0,   0,   0, 248,   0,   0,   0,   0,   1, 240,   0,   0,   0,
       0,   3, 224,   0,   0,   0,   0,   7, 128,   0,   0,   0,   0,  15,   0,
       0,   0,   0,   0,  62,   0,   0,   0,   0,   0, 124,   0,   0,   0,   0,
       0,  56,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,  24,   0,
       0,   0,   0,   0, 240,   0,   0,   0,   0,   3, 240,   0,   0,   0,   0,
      31, 240,   0,   0,   0,   0, 127, 240,   0,   0,   0,   3, 255, 240,   0,
       0,   0,   3, 255, 224,   0,   0,   0,   1, 255, 224,   0,   0,   0,   0,
     255, 224,   0,   0,   0,   0, 127, 224,   0,   0,   0,   0,  63, 224,   0,
       0,   0,   0, 127, 192,   0,   0,   0,   0, 247, 192,   0,   0,   0,   1,
     227, 192,   0,   0,   0,   3, 193, 192,   0,   0,   0,   3, 192, 192,   0,
       0,   0,   7, 128,   0,   0,   0,   0,  15,   0,   0,   0,   0,   0,  30,
       0,   0,   0,   0,   0,  60,   0,   0,   0,   0,   0, 120,   0,   0,   0,
       0,   0, 120,   0,   0,   0,   0,   0, 240,   0,   0,   0,   0,   1, 224,
       0,   0,   0,   0,   3, 192,   0,   0,   0,   0,   7, 128,   0,   0,   0,
       0,  15,   0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  14,   0,
       0,   0,   0,   0,   4,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,  64,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   7, 192,   0,
       0,   0,   0,  15, 192,   0,   0,   0,   0,  63, 192,   0,   0,   0,   0,
     127, 192,   0,   0,   0,   1, 255, 192,   0,   0,   0,   7, 255, 192,   0,
       0,   0,  15, 255, 192,   0,   0,   0,   7, 255, 192,   0,   0,   0,   1,
     255, 192,   0,   0,   0,   0, 255, 192,   0,   0,   0,   0, 127, 192,   0,
       0,   0,   0, 255, 192,   0,   0,   0,   0, 227, 192,   0,   0,   0,   1,
     225, 128,   0,   0,   0,   1, 192,   0,   0,   0,   0,   3, 128,   0,   0,
       0,   0,   7, 128,   0,   0,   0,   0,   7,   0,   0,   0,   0,   0,  15,
       0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  30,   0,   0,   0,
       0,   0,  28,   0,   0,   0,   0,   0,  56,   0,   0,   0,   0,   0, 120,
       0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0, 240,   0,   0,   0,
       0,   0, 224,   0,   0,   0,   0,   1, 224,   0,   0,   0,   0,   3, 192,
       0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   1, 128,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   6,   0,   0,   0,   0,   0,
      14,   0,   0,   0,   0,   0,  30,   0,   0,   0,   0,   0,  62,   0,   0,
       0,   0,   0, 127,   0,   0,   0,   0,   0, 255,   0,   0,   0,   0,   1,
     255,   0,   0,   0,   0,   3, 255,   0,   0,   0,   0,  15, 255,   0,   0,
       0,   0,  31, 255,   0,   0,   0,   0,  63, 255,   0,   0,   0,   0,   7,
     255, 128,   0,   0,   0,   0, 255, 128,   0,   0,   0,   0, 255, 128,   0,
       0,   0,   0, 231, 128,   0,   0,   0,   1, 224, 128,   0,   0,   0,   1,
     192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   3, 128,   0,   0,
       0,   0,   3, 128,   0,   0,   0,   0,   7, 128,   0,   0,   0,   0,   7,
       0,   0,   0,   0,   0,   7,   0,   0,   0,   0,   0,  15,   0,   0,   0,
       0,   0,  14,   0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  30,
       0,   0,   0,   0,   0,  28,   0,   0,   0,   0,   0,  28,   0,   0,   0,
       0,   0,  56,   0,   0,   0,   0,   0,  56,   0,   0,   0,   0,   0, 120,
       0,   0,   0,   0,   0, 112,   0,   0,   0,   0,   0, 112,   0,   0,   0,
       0,   0, 112,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0},
  {     0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,  16,   0,   0,
       0,   0,   0,  16,   0,   0,   0,   0,   0,  48,   0,   0,   0,   0,   0,
     120,   0,   0,   0,   0,   0, 248,   0,   0,   0,   0,   1, 248,   0,   0,
       0,   0,   1, 248,   0,   0,   0,   0,   3, 252,   0,   0,   0,   0,   7,
     252,   0,   0,   0,   0,  15, 252,   0,   0,   0,   0,  31, 254,   0,   0,
       0,   0,  31, 254,   0,   0,   0,   0,  63, 254,   0,   0,   0,   0, 127,
     255,   0,   0,   0,   0,   3, 255,   0,   0,   0,   0,   1, 223,   0,   0,
       0,   0,   1, 192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   1,
     192,   0,   0,   0,   0,   1, 192,   0,   0,   0,   0,   3, 128,   0,   0,
       0,   0,   3, 128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   3,
     128,   0,   0,   0,   0,   3, 128,   0,   0,   0,   0,   3, 128,   0,   0,
       0,   0,   7,   0,   0,   0,   0,   0,   7,   0,   0,   0,   0,   0,   7,
       0,   0,   0,   0,   0,   7,   0,   0,   0,   0,   0,   7,   0,   0,   0,
       0,   0,  14,   0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  14,
       0,   0,   0,   0,   0,  14,   0,   0,   0,   0,   0,  14,   0,   0,   0,
       0,   0,  14,   0,   0,   0,   0,   0,  12,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
       0,   0,   0}
};
// ─── Libraries ────────────────────────────────────────────────────────────────
#include <Wire.h>
#include <Adafruit_GFX.h>
#include <Adafruit_SH110X.h>
#include <TinyGPS++.h>
#include <EEPROM.h>
#include <math.h>
#include <WiFi.h>
#include <WiFiClientSecure.h>
#include <PubSubClient.h>
#include <ArduinoJson.h>
#include "esp_eap_client.h"
#define WHITE SH110X_WHITE
#define BLACK SH110X_BLACK

// ─── Display / GPS ────────────────────────────────────────────────────────────
#define SCREEN_WIDTH   128
#define SCREEN_HEIGHT   64
#define OLED_RESET      -1
#define SCREEN_ADDRESS  0x3C
#define FRAME_WIDTH     48
#define FRAME_HEIGHT    48
#define FRAME_COUNT     (sizeof(frames) / sizeof(frames[0]))

#define GPS_SERIAL Serial2
#define EEPROM_SIZE 2048

// ─── Rocker button pins ───────────────────────────────────────────────────────
#define BTN_UP    32
#define BTN_DOWN  33
#define BTN_LEFT  25
#define BTN_RIGHT 26
#define BTN_PRESS 27

// ─── Frame offset ─────────────────────────────────────────────────────────────
#define FRAME_OFFSET  18

// ─── Tilt warning threshold ───────────────────────────────────────────────────
#define TILT_WARN_DEG  30.0f

// ─── LSM303 I2C addresses ─────────────────────────────────────────────────────
#define LSM303_ACCEL_ADDR  0x19
#define LSM303_MAG_ADDR    0x1E

// ─── LSM303 Calibration ───────────────────────────────────────────────────────
float mag_x_offset = 0, mag_y_offset = 0, mag_z_offset = 0;
float mag_x_scale  = 1, mag_y_scale  = 1, mag_z_scale  = 1;

// ─── MQTT broker ──────────────────────────────────────────────────────────────
#define MQTT_HOST      "f2e56e6599344b86aa506ab8bc78ce52.s1.eu.hivemq.cloud"
#define MQTT_PORT      8883
#define MQTT_USER      "lodestone"
#define MQTT_PASS      "Lode$tone2026"
#define MQTT_INTERVAL  5000    // publish position every 5 s

WiFiClientSecure wifiSecure;
PubSubClient     mqtt(wifiSecure);
unsigned long lastMqttSend    = 0;
unsigned long lastAnnounce    = 0;
bool wifiConnected = false;
char pairedMacs[10][20];
int  pairedMacCount = 0;
bool mqttConnected = false;
String myMacStr      = "";    // set in setup()
char   deviceName[32]  = "Lodestone";  // user-configurable name
char   pendingPairName[16] = "";
String pendingPairMac  = "";

// ─── Sleep / display timeout ──────────────────────────────────────────────────
unsigned long lastActivityTime = 0;
bool displaySleeping = false;
uint8_t sleepTimeoutMin = 1;   // default 1 minute (0 = never)


// ─── Discovered devices ───────────────────────────────────────────────────────
#define MAX_DEVICES 10
struct DiscoveredDevice {
  char    name[16];
  double  lat;
  double  lon;
  float   heading;
  uint8_t mac[6];
  unsigned long lastSeen;
  bool    isHardware;   // true = Lodestone device, false = app client
};
DiscoveredDevice nearbyDevices[MAX_DEVICES];
int nearbyCount    = 0;
int selectedDevice = 0;
// App (phone) clients
struct AppClient {
  char   name[32];  // username set in app
  char   mac[20];   // mac string
  unsigned long lastSeen;
};
AppClient appClients[10];
int appClientCount = 0;
char inboxMsgs[5][64];   // last 5 messages received
int  inboxCount = 0;
char composeMsg[64] = "";  // message being typed
int  composeMsgLen  = 0;
int  msgTarget = -1;  // -1=broadcast, 0..N=specific appClient index

// ─── WiFi credentials — up to 5 saved networks ───────────────────────────────
#define MAX_SAVED_WIFI 5
struct SavedNetwork {
  char ssid[32];
  char username[32];
  char password[64];
  bool enterprise;
  uint8_t pad[3];   // align to 132 bytes total
};
SavedNetwork savedNetworks[MAX_SAVED_WIFI];
int savedNetworkCount  = 0;   // how many are stored
int activeNetworkIdx   = -1;  // which one is currently connected (-1 = none)
int pendingNetworkIdx  = 0;   // slot being configured right now
#define WIFI_EEPROM_ADDR     340
#define SETTINGS_EEPROM_ADDR 1100  // well clear of WiFi data (ends ~1001)
#define PAIRED_EEPROM_ADDR   1200  // save paired MACs (10 * 20 bytes = 200)
// Helper: current working config (points into savedNetworks)
SavedNetwork& currentNet() {
  static SavedNetwork tmp;
  if (activeNetworkIdx >= 0 && activeNetworkIdx < savedNetworkCount)
    return savedNetworks[activeNetworkIdx];
  return tmp;
}

String inputPassword = "";
String inputUsername  = "";

// ─── WiFi scan ────────────────────────────────────────────────────────────────
#define MAX_NETWORKS 8
String scannedSSIDs[MAX_NETWORKS];
int    scannedRSSI[MAX_NETWORKS];
int networkCount = 0;
int networkIndex = 0;

// ─── Password character sets ──────────────────────────────────────────────────
const char capsChars[]    = "ABCDEFGHIJKLMNOPQRSTUVWXYZ";
const char lowerChars[]   = "abcdefghijklmnopqrstuvwxyz";
const char digitChars[]   = "0123456789";
const char specialChars[] = "!@#$%^&*()-_=+[]{}|;:',.<>?/ ";

enum CharSet { CAPS, LOWER, DIGITS, SPECIAL };
CharSet activeSet = CAPS;

const char* getCurrentChars() {
  switch (activeSet) {
    case CAPS:    return capsChars;
    case LOWER:   return lowerChars;
    case DIGITS:  return digitChars;
    case SPECIAL: return specialChars;
  }
  return capsChars;
}

int getCurrentCharsLen() {
  return strlen(getCurrentChars());
}

// ─── Location struct ──────────────────────────────────────────────────────────
struct Location {
  char   name[16];
  double lat;
  double lon;
};

Location locations[10];
int locationCount = 0;

double TARGET_LAT = 0.0;
double TARGET_LON = 0.0;
char   TARGET_NAME[16] = "";
bool   navActive  = false;

// ─── App state machine ────────────────────────────────────────────────────────
enum State {
  MAIN_MENU,
  DIR_FINDER_MENU,
  SELECT_COORD,
  DELETE_LOCATION,
  DELETE_CONFIRM,
  KEYPAD_NAME,
  INPUT_LAT,
  INPUT_LON,
  SAVE_CONFIRM,
  SAVE_ERROR,
  NAVIGATING,
  COMPASS,
  DEVICE_TRACKER_MENU,
  WIFI_SCAN,
  WIFI_TYPE_SELECT,
  WIFI_SETUP_USER,
  WIFI_SETUP_PASS,
  DEVICE_TRACKER,
  DEVICE_TRACKING,
  PAIR_LODESTONE,
  UNPAIR_CONFIRM,
  SETTINGS_MENU,
  SLEEP_SET,
  SPEEDOMETER,
  PAIR_REQUEST,
  DEVICE_NAME_INPUT,
  CONNECT_APP,
  MSG_TARGET_SELECT,
  MSG_COMPOSE,
  MSG_INBOX
};
State state = MAIN_MENU;

// ─── Menu ─────────────────────────────────────────────────────────────────────
const char* menuItems[] = {
  "DIRECTION FINDER",
  "COMPASS",
  "DEVICE TRACKER",
  "CALIBRATE",
  "SPEEDOMETER",
  "SETTINGS"
};
const char* settingsItems[] = {
  "WIFI SETUP",
  "DISCONNECT WIFI",
  "DEVICE NAME",
  "BLUETOOTH",
  "SLEEP TIME"
};
// DIRECTION FINDER sub-menu items
const char* dirFinderItems[] = {
  "SELECT LOCATION",
  "ADD LOCATION",
  "DELETE LOCATION"
};
// DEVICE TRACKER sub-menu items
const char* deviceTrackerItems[] = {
  "TRACK LODESTONE",
  "PAIR LODESTONE",
  "CONNECT APP",
  "MESSAGES"
};
int menuIndex = 0;

// ─── Name / coord input ───────────────────────────────────────────────────────
char   nameChars[] = "ABCDEFGHIJKLMNOPQRSTUVWXYZ0123456789 ";
int    charIndex   = 0;
String inputName   = "";
String saveErrorMsg = "";

char   numChars[]  = "0123456789.-";
int    numIndex    = 0;
String coordInput  = "";
double tempLat     = 0;
double tempLon     = 0;

// ─── Objects ──────────────────────────────────────────────────────────────────
Adafruit_SH1106G display = Adafruit_SH1106G(128, 64, &Wire, OLED_RESET);
TinyGPSPlus      gps;

// Forward declarations (used by draw functions before their definitions)
bool isAlreadyPaired(const String& mac);
bool isNearbyDevicePaired(int idx);
void removePairedDevice(const String& mac);
void resubscribePaired();

// ─── Sleep / settings helpers ────────────────────────────────────────────────
void resetActivity() {
  lastActivityTime = millis();
  if (displaySleeping) {
    Wire.beginTransmission(SCREEN_ADDRESS);
    Wire.write(0x00); Wire.write(0xAF);  // SH1106G display ON
    Wire.endTransmission();
    displaySleeping = false;
  }
}

void checkSleep() {
  if (sleepTimeoutMin == 0) return;
  if (state != MAIN_MENU) { lastActivityTime = millis(); return; }
  if (!displaySleeping &&
      millis() - lastActivityTime > (unsigned long)sleepTimeoutMin * 60000UL) {
    display.clearDisplay();
    display.display();
    Wire.beginTransmission(SCREEN_ADDRESS);
    Wire.write(0x00); Wire.write(0xAE);  // SH1106G display OFF
    Wire.endTransmission();
    displaySleeping = true;
  }
}

// ─── Settings struct ──────────────────────────────────────────────────────────
struct Settings {
  uint8_t sleepTimeoutMin;  // 0=never,1,2,5
  char    deviceName[32];   // user-set name
  uint8_t pad[12];
};

void saveSettings() {
  Settings s;
  s.sleepTimeoutMin = sleepTimeoutMin;
  strncpy(s.deviceName, deviceName, 31); s.deviceName[31] = '\0';
  memset(s.pad, 0, sizeof(s.pad));
  EEPROM.put(SETTINGS_EEPROM_ADDR, s);
  EEPROM.commit();
}

void loadSettings() {
  Settings s;
  EEPROM.get(SETTINGS_EEPROM_ADDR, s);
  if (s.sleepTimeoutMin <= 5) sleepTimeoutMin = s.sleepTimeoutMin;
  else sleepTimeoutMin = 1;
  if (s.deviceName[0] >= 32 && s.deviceName[0] <= 126)
    strncpy(deviceName, s.deviceName, 31);
}

// ─── Sensor fusion state ──────────────────────────────────────────────────────
float filteredHeading = 0.0f;

// Accelerometer median filter (3-sample)
#define ACCEL_MEDIAN_N 3
float accelBufX[ACCEL_MEDIAN_N] = {0};
float accelBufY[ACCEL_MEDIAN_N] = {0};
float accelBufZ[ACCEL_MEDIAN_N] = {0};
uint8_t accelBufIdx = 0;

// Smoothed roll/pitch for tilt compensation
float smoothRoll  = 0.0f;
float smoothPitch = 0.0f;

// Smoothed navigation outputs
float smoothBearing  = -1.0f;   // -1 = uninitialised
float smoothDist     = -1.0f;
float smoothRelAngle = 0.0f;

// =============================================================================
//  LSM303 LOW-LEVEL
// =============================================================================
void writeReg(uint8_t addr, uint8_t reg, uint8_t val) {
  Wire.beginTransmission(addr);
  Wire.write(reg);
  Wire.write(val);
  Wire.endTransmission();
}

void readAccelRaw(float &ax, float &ay, float &az) {
  Wire.beginTransmission(LSM303_ACCEL_ADDR);
  Wire.write(0x28 | 0x80);
  Wire.endTransmission(false);
  Wire.requestFrom(LSM303_ACCEL_ADDR, (uint8_t)6);
  int16_t rawX = (Wire.read() | (Wire.read() << 8));
  int16_t rawY = (Wire.read() | (Wire.read() << 8));
  int16_t rawZ = (Wire.read() | (Wire.read() << 8));
  ax = rawX * 0.001f;
  ay = rawY * 0.001f;
  az = rawZ * 0.001f;
}

// Median of 3 helper
static float med3(float a, float b, float c) {
  if (a > b) { float t = a; a = b; b = t; }
  if (b > c) { float t = b; b = c; c = t; }
  if (a > b) { float t = a; a = b; b = t; }
  return b;
}

// Read accelerometer through a 3-sample median filter
void readAccel(float &ax, float &ay, float &az) {
  float rx, ry, rz;
  readAccelRaw(rx, ry, rz);
  accelBufX[accelBufIdx] = rx;
  accelBufY[accelBufIdx] = ry;
  accelBufZ[accelBufIdx] = rz;
  accelBufIdx = (accelBufIdx + 1) % ACCEL_MEDIAN_N;
  ax = med3(accelBufX[0], accelBufX[1], accelBufX[2]);
  ay = med3(accelBufY[0], accelBufY[1], accelBufY[2]);
  az = med3(accelBufZ[0], accelBufZ[1], accelBufZ[2]);
}

void readMag(float &mx, float &my, float &mz) {
  Wire.beginTransmission(LSM303_MAG_ADDR);
  Wire.write(0x03);
  Wire.endTransmission(false);
  Wire.requestFrom(LSM303_MAG_ADDR, (uint8_t)6);
  int16_t rawX = (Wire.read() << 8) | Wire.read();
  int16_t rawZ = (Wire.read() << 8) | Wire.read();
  int16_t rawY = (Wire.read() << 8) | Wire.read();
  mx = rawX / 1100.0f;
  my = rawY / 1100.0f;
  mz = rawZ /  980.0f;
}

// =============================================================================
//  CALIBRATION
// =============================================================================
void runCalibration() {
  // ── Intro — allow exit with BTN_LEFT ─────────────────────────────────────
  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(30, 0);  display.print("CALIBRATION");
  display.setCursor(0, 14); display.print("Move device in a");
  display.setCursor(0, 24); display.print("figure-8 pattern");
  display.setCursor(25, 38); display.print("Press to start");
  display.display();

  // Wait for PRESS to start, LEFT to cancel
  while (true) {
    if (btnPressed(BTN_PRESS)) break;
    if (btnPressed(BTN_LEFT))  { state = MAIN_MENU; menuIndex = 0; return; }
  }

  float x_min =  99999, x_max = -99999;
  float y_min =  99999, y_max = -99999;
  float z_min =  99999, z_max = -99999;

  // We define "done" as achieving >= TARGET_SPREAD on all three axes.
  // A good figure-8 in Earth's field typically gives ~0.4-0.8 Gauss spread.
  // We use a lower threshold and cap at 100% so progress feels natural.
  const float TARGET_SPREAD = 0.60f;   // Gauss — tunable
  // Also enforce a minimum sample count so a single twitch can't finish it
  const int   MIN_SAMPLES   = 80;      // ~8 seconds at 100ms per sample
  int samples = 0;

  while (true) {
    float mx, my, mz;
    readMag(mx, my, mz);
    if (mx < x_min) x_min = mx;  if (mx > x_max) x_max = mx;
    if (my < y_min) y_min = my;  if (my > y_max) y_max = my;
    if (mz < z_min) z_min = mz;  if (mz > z_max) z_max = mz;
    samples++;

    // Progress = min coverage across all three axes, capped at 100%
    float px = (x_max - x_min) / TARGET_SPREAD;
    float py = (y_max - y_min) / TARGET_SPREAD;
    float pz = (z_max - z_min) / TARGET_SPREAD;
    float pMin = px < py ? px : py;
          pMin = pMin < pz ? pMin : pz;
    if (pMin > 1.0f) pMin = 1.0f;
    int barW = (int)(pMin * 126);

    display.clearDisplay();
    display.setTextSize(1);
    display.setCursor(22, 0); display.print("CALIBRATING");
    display.setCursor(4, 14); display.print("Keep moving in");
    display.setCursor(16, 24); display.print("figure-8...");

    // Progress bar — outline + fill
    display.drawRect(1, 40, 126, 14, WHITE);
    if (barW > 0) display.fillRect(1, 40, barW, 14, WHITE);

    // Percentage inside bar (inverted colour over filled part)
    int pct = (int)(pMin * 100);
    display.setTextColor(pct > 50 ? BLACK : WHITE);
    display.setCursor(52, 44); display.print(pct); display.print("%");
    display.setTextColor(WHITE);

    display.display();
    delay(100);

    // Done when all axes sufficiently covered AND minimum samples collected
    if (pMin >= 1.0f && samples >= MIN_SAMPLES) break;
  }

  // ── Compute offsets & scales ───────────────────────────────────────────────
  mag_x_offset = (x_max + x_min) / 2.0f;
  mag_y_offset = (y_max + y_min) / 2.0f;
  mag_z_offset = (z_max + z_min) / 2.0f;

  float x_range   = (x_max - x_min) / 2.0f;
  float y_range   = (y_max - y_min) / 2.0f;
  float z_range   = (z_max - z_min) / 2.0f;
  float avg_range = (x_range + y_range + z_range) / 3.0f;
  mag_x_scale = (x_range > 0.001f) ? avg_range / x_range : 1.0f;
  mag_y_scale = (y_range > 0.001f) ? avg_range / y_range : 1.0f;
  mag_z_scale = (z_range > 0.001f) ? avg_range / z_range : 1.0f;

  // ── Done ──────────────────────────────────────────────────────────────────
  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(20, 10); display.print("CALIBRATION");
  display.setCursor(28, 24); display.print("COMPLETE!");
  display.setCursor(10, 42); display.print("Your compass is");
  display.setCursor(16, 52); display.print("ready to use.");
  display.display();
  delay(2500);
  state = MAIN_MENU;
  menuIndex = 0;
}

// =============================================================================
//  HEADING  — adaptive-alpha circular complementary filter
// =============================================================================
float getHeading() {
  float ax, ay, az, mx, my, mz;
  readAccel(ax, ay, az);
  readMag(mx, my, mz);

  // Hard-iron correction + soft-iron scale
  float cx = (mx - mag_x_offset) * mag_x_scale;
  float cy = (my - mag_y_offset) * mag_y_scale;
  float cz = (mz - mag_z_offset) * mag_z_scale;

  // Normalise accelerometer
  float norm = sqrtf(ax*ax + ay*ay + az*az);
  if (norm < 0.1f) return filteredHeading;   // sensor error guard
  ax /= norm; ay /= norm; az /= norm;

  // Tilt-compensation via full rotation matrix:
  // East vector  E = A x M (normalised)
  // North vector N = E x A
  float Ex = ay*cz - az*cy;
  float Ey = az*cx - ax*cz;
  float Ez = ax*cy - ay*cx;
  float eNorm = sqrtf(Ex*Ex + Ey*Ey + Ez*Ez);
  if (eNorm < 1e-6f) return filteredHeading;
  Ex /= eNorm; Ey /= eNorm; Ez /= eNorm;

  float Nx = Ey*az - Ez*ay;
  float Ny = Ez*ax - Ex*az;   // full N vector (improves accuracy near poles)

  float h = atan2f(-Ex, Nx) * 180.0f / PI;
  (void)Ny;                    // suppress unused-variable warning
  if (h < 0.0f)    h += 360.0f;
  if (h >= 360.0f) h -= 360.0f;

  // Adaptive alpha: slow filter when heading is stable, faster when rotating
  float diff = h - filteredHeading;
  if (diff >  180.0f) diff -= 360.0f;
  if (diff < -180.0f) diff += 360.0f;
  float absDiff = fabsf(diff);

  // Alpha rises from 0.08 (stable) to 0.35 (fast rotation > 30 deg/step)
  float alpha = 0.08f + 0.27f * constrain(absDiff / 30.0f, 0.0f, 1.0f);

  // Circular (unit-vector) blend to avoid 0/360 wrap artefacts
  float hRad = h              * (PI / 180.0f);
  float fRad = filteredHeading * (PI / 180.0f);
  float sinF = (1.0f - alpha) * sinf(fRad) + alpha * sinf(hRad);
  float cosF = (1.0f - alpha) * cosf(fRad) + alpha * cosf(hRad);
  filteredHeading = atan2f(sinF, cosF) * (180.0f / PI);
  if (filteredHeading < 0.0f) filteredHeading += 360.0f;
  return filteredHeading;
}

// =============================================================================
//  TILT  — EMA-smoothed roll & pitch
// =============================================================================
void getTilt(float &roll, float &pitch) {
  float ax, ay, az;
  readAccel(ax, ay, az);
  float norm = sqrtf(ax*ax + ay*ay + az*az);
  if (norm < 0.1f) { roll = smoothRoll; pitch = smoothPitch; return; }
  ax /= norm; ay /= norm; az /= norm;

  float rawRoll  = atan2f(ay, az)                    * (180.0f / PI);
  float rawPitch = atan2f(-ax, sqrtf(ay*ay + az*az)) * (180.0f / PI);

  // EMA alpha 0.2 — smooth but still responsive
  const float a = 0.2f;
  smoothRoll  = (1.0f - a) * smoothRoll  + a * rawRoll;
  smoothPitch = (1.0f - a) * smoothPitch + a * rawPitch;

  roll  = smoothRoll;
  pitch = smoothPitch;
}

// =============================================================================
//  BUTTON HELPER
// =============================================================================
bool btnPressed(int pin) {
  if (!digitalRead(pin)) {
    delay(200);
    return true;
  }
  return false;
}

// =============================================================================
//  EEPROM — Locations
// =============================================================================
void saveLocations() {
  int addr = 0;
  EEPROM.write(addr, locationCount);
  addr++;
  for (int i = 0; i < locationCount; i++) {
    EEPROM.put(addr, locations[i]);
    addr += sizeof(Location);
  }
  EEPROM.commit();
  publishLocations();  // keep app in sync
}

void loadLocations() {
  int addr = 0;
  locationCount = EEPROM.read(addr);
  addr++;
  if (locationCount > 10) locationCount = 0;
  for (int i = 0; i < locationCount; i++) {
    EEPROM.get(addr, locations[i]);
    addr += sizeof(Location);
  }
}

// =============================================================================
//  EEPROM — WiFi config
// =============================================================================
void saveWiFiNetworks() {
  int addr = WIFI_EEPROM_ADDR;
  EEPROM.write(addr, (uint8_t)savedNetworkCount); addr++;
  for (int i = 0; i < MAX_SAVED_WIFI; i++) {
    EEPROM.put(addr, savedNetworks[i]); addr += sizeof(SavedNetwork);
  }
  EEPROM.commit();
}

void loadWiFiNetworks() {
  int addr = WIFI_EEPROM_ADDR;
  savedNetworkCount = EEPROM.read(addr); addr++;
  if (savedNetworkCount > MAX_SAVED_WIFI || savedNetworkCount < 0)
    savedNetworkCount = 0;
  for (int i = 0; i < MAX_SAVED_WIFI; i++) {
    EEPROM.get(addr, savedNetworks[i]); addr += sizeof(SavedNetwork);
    // validate
    if (savedNetworks[i].ssid[0] < 32 || savedNetworks[i].ssid[0] > 126)
      memset(&savedNetworks[i], 0, sizeof(SavedNetwork));
  }
}

// Try each saved network in order, connect to first that succeeds
void autoConnectWiFi() {
  for (int i = 0; i < savedNetworkCount; i++) {
    if (strlen(savedNetworks[i].ssid) == 0) continue;
    display.clearDisplay();
    display.setTextSize(1);
    display.setCursor(0, 0);  display.print("Connecting...");
    display.setCursor(0, 12); display.print(savedNetworks[i].ssid);
    display.display();

    WiFi.disconnect(true);
    WiFi.mode(WIFI_STA);
    if (savedNetworks[i].enterprise) {
      esp_eap_client_set_identity((uint8_t*)savedNetworks[i].username, strlen(savedNetworks[i].username));
      esp_eap_client_set_username((uint8_t*)savedNetworks[i].username, strlen(savedNetworks[i].username));
      esp_eap_client_set_password((uint8_t*)savedNetworks[i].password, strlen(savedNetworks[i].password));
      esp_wifi_sta_enterprise_enable();
      WiFi.begin(savedNetworks[i].ssid);
    } else {
      WiFi.begin(savedNetworks[i].ssid, savedNetworks[i].password);
    }
    int attempts = 0;
    while (WiFi.status() != WL_CONNECTED && attempts < 14) {
      delay(400); attempts++;
    }
    if (WiFi.status() == WL_CONNECTED) {
      wifiConnected = true;
      activeNetworkIdx = i;
      display.clearDisplay();
      display.setCursor(0, 0);  display.print("Connected!");
      display.setCursor(0, 12); display.print(savedNetworks[i].ssid);
      display.setCursor(0, 24); display.print(WiFi.localIP().toString());
      display.display();
      delay(1500);
      return;
    }
  }
  wifiConnected = false;
  activeNetworkIdx = -1;
}

// Connect a specific network by index — directly, no scanning other saved networks
void connectNetworkByIndex(int idx) {
  if (idx < 0 || idx >= savedNetworkCount) return;
  WiFi.disconnect(true);
  WiFi.mode(WIFI_STA);
  delay(100);
  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(0, 0);  display.print("Connecting...");
  display.setCursor(0, 12); display.print(savedNetworks[idx].ssid);
  display.display();
  if (savedNetworks[idx].enterprise) {
    esp_eap_client_set_identity((uint8_t*)savedNetworks[idx].username, strlen(savedNetworks[idx].username));
    esp_eap_client_set_username((uint8_t*)savedNetworks[idx].username, strlen(savedNetworks[idx].username));
    esp_eap_client_set_password((uint8_t*)savedNetworks[idx].password, strlen(savedNetworks[idx].password));
    esp_wifi_sta_enterprise_enable();
    WiFi.begin(savedNetworks[idx].ssid);
  } else {
    WiFi.begin(savedNetworks[idx].ssid, savedNetworks[idx].password);
  }
  int att = 0;
  while (WiFi.status() != WL_CONNECTED && att < 20) { delay(400); att++; }
  if (WiFi.status() == WL_CONNECTED) {
    wifiConnected = true; activeNetworkIdx = idx;
    display.clearDisplay();
    display.setCursor(0, 0);  display.print("Connected!");
    display.setCursor(0, 12); display.print(savedNetworks[idx].ssid);
    display.setCursor(0, 24); display.print(WiFi.localIP().toString());
    display.display(); delay(1500);
  } else {
    wifiConnected = false;
    display.clearDisplay();
    display.setCursor(0, 0);  display.print("Failed!");
    display.setCursor(0, 12); display.print(savedNetworks[idx].ssid);
    display.setCursor(0, 24); display.print("Check credentials");
    display.display(); delay(1500);
  }
}

// Legacy stub — used by old connectWiFi() call chain
void saveWiFiConfig()   { saveWiFiNetworks(); }
void loadWiFiConfig()   { loadWiFiNetworks(); }
void connectWiFi()      { autoConnectWiFi(); }

// =============================================================================
//  WiFi — Personal (WPA2)
// =============================================================================
void connectWiFiPersonal() { connectNetworkByIndex(activeNetworkIdx >= 0 ? activeNetworkIdx : 0); }

// =============================================================================
//  WiFi — Enterprise (WPA2-EAP / LDAP)
// =============================================================================
void connectWiFiEnterprise() { connectNetworkByIndex(activeNetworkIdx >= 0 ? activeNetworkIdx : 0); }

// =============================================================================
//  WiFi — auto select type and connect
// =============================================================================
// =============================================================================
//  WiFi — scan networks
// =============================================================================
void scanNetworks() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(0, 0); display.print("Scanning WiFi...");
  display.display();

  // Ensure radio is in a clean STA state before scanning.
  // If we're stuck in a failed connection the scan returns 0 otherwise.
  WiFi.disconnect(true);   // disconnect + clear credentials
  WiFi.mode(WIFI_STA);
  delay(100);              // give the radio a moment to settle

  int n = WiFi.scanNetworks(/*async=*/false, /*show_hidden=*/false);

  // n == -1 (WIFI_SCAN_FAILED) or -2 (WIFI_SCAN_RUNNING) means something
  // went wrong — retry once after a longer settle time.
  if (n < 0) {
    display.setCursor(0, 14); display.print("Retrying...");
    display.display();
    WiFi.scanDelete();
    delay(500);
    n = WiFi.scanNetworks(false, false);
  }

  networkCount = 0;
  if (n > 0) {
    for (int i = 0; i < n && networkCount < MAX_NETWORKS; i++) {
      scannedSSIDs[networkCount] = WiFi.SSID(i);
      scannedRSSI[networkCount]  = WiFi.RSSI(i);
      networkCount++;
    }
  }
  WiFi.scanDelete();  // free scan memory

  if (networkCount == 0) {
    display.clearDisplay();
    display.setCursor(0, 0);  display.print("No networks found!");
    display.display();
    delay(2000);
    state = MAIN_MENU; menuIndex = 0;
  }
}

// =============================================================================
//  UDP — broadcast my position
// =============================================================================
// =============================================================================
//  MQTT — callback (incoming messages)
// =============================================================================
void mqttCallback(char* topic, byte* payload, unsigned int length) {
  String t = String(topic);
  String msg = "";
  for (unsigned int i = 0; i < length; i++) msg += (char)payload[i];

  StaticJsonDocument<512> doc;
  if (deserializeJson(doc, msg) != DeserializationError::Ok) return;

  // ── Announce from another device ──────────────────────────────────────────
  if (t == "lodestone/announce") {
    String mac = doc["mac"] | "";
    if (mac == myMacStr || mac == "") return;
    const char* name = doc["name"] | "Unknown";
    // (dedupe by full MAC happens further down)
    bool hw = (String(doc["type"] | "") == "hardware");
    bool isApp = (String(doc["type"] | "") == "app");
    // Track app clients separately
    if (isApp) {
      bool found = false;
      for (int i = 0; i < appClientCount; i++) {
        if (String(appClients[i].mac) == mac) {
          strncpy(appClients[i].name, name, 31);
          appClients[i].lastSeen = millis();
          found = true; break;
        }
      }
      if (!found && appClientCount < 10) {
        strncpy(appClients[appClientCount].name, name, 31);
        strncpy(appClients[appClientCount].mac, mac.c_str(), 19);
        appClients[appClientCount].lastSeen = millis();
        appClientCount++;
      }
    }
    // Update existing by mac string
    bool updated = false;
    for (int i = 0; i < nearbyCount; i++) {
      char storedMac[20];
      snprintf(storedMac, sizeof(storedMac), "%02X:%02X:%02X:%02X:%02X:%02X",
               nearbyDevices[i].mac[0],nearbyDevices[i].mac[1],nearbyDevices[i].mac[2],
               nearbyDevices[i].mac[3],nearbyDevices[i].mac[4],nearbyDevices[i].mac[5]);
      if (mac == String(storedMac)) {
        nearbyDevices[i].lastSeen  = millis();
        nearbyDevices[i].isHardware = hw;
        strncpy(nearbyDevices[i].name, name, 15);
        updated = true; break;
      }
    }
    if (!updated && nearbyCount < MAX_DEVICES) {
      strncpy(nearbyDevices[nearbyCount].name, name, 15);
      nearbyDevices[nearbyCount].lastSeen   = millis();
      nearbyDevices[nearbyCount].lat        = 0;
      nearbyDevices[nearbyCount].lon        = 0;
      nearbyDevices[nearbyCount].heading    = 0;
      nearbyDevices[nearbyCount].isHardware = hw;
      // Parse mac string into bytes
      int m0,m1,m2,m3,m4,m5;
      if (sscanf(mac.c_str(), "%X:%X:%X:%X:%X:%X",&m0,&m1,&m2,&m3,&m4,&m5)==6) {
        nearbyDevices[nearbyCount].mac[0]=m0; nearbyDevices[nearbyCount].mac[1]=m1;
        nearbyDevices[nearbyCount].mac[2]=m2; nearbyDevices[nearbyCount].mac[3]=m3;
        nearbyDevices[nearbyCount].mac[4]=m4; nearbyDevices[nearbyCount].mac[5]=m5;
      }
      nearbyCount++;
    }
  }

  // ── Position update from paired device ────────────────────────────────────
  String pairPrefix = "lodestone/pair/";
  if (t.startsWith(pairPrefix)) {
    String mac = doc["mac"] | "";
    if (mac == myMacStr || mac.length() == 0) return;
    // Only accept from actually-paired devices
    String _pm = mac; _pm.replace(":", "");
    if (!isAlreadyPaired(_pm)) return;
    double lat = doc["lat"] | 0.0;
    double lon = doc["lon"] | 0.0;
    float  hdg = doc["heading"] | 0.0f;
    const char* name = doc["name"] | "Device";
    // Match by MAC bytes
    int mm0,mm1,mm2,mm3,mm4,mm5;
    if (sscanf(mac.c_str(), "%X:%X:%X:%X:%X:%X",&mm0,&mm1,&mm2,&mm3,&mm4,&mm5) != 6) return;
    for (int i = 0; i < nearbyCount; i++) {
      if (nearbyDevices[i].mac[0]==mm0 && nearbyDevices[i].mac[1]==mm1 &&
          nearbyDevices[i].mac[2]==mm2 && nearbyDevices[i].mac[3]==mm3 &&
          nearbyDevices[i].mac[4]==mm4 && nearbyDevices[i].mac[5]==mm5) {
        nearbyDevices[i].lat      = lat;
        nearbyDevices[i].lon      = lon;
        nearbyDevices[i].heading  = hdg;
        nearbyDevices[i].lastSeen = millis();
        strncpy(nearbyDevices[i].name, name, 15);
        return;
      }
    }
  }

  // ── Pair request from app ─────────────────────────────────────────────────
  String reqTopic = "lodestone/request/" + myMacStr;
  reqTopic.replace(":", "");
  if (t == reqTopic) {
    const char* requesterName = doc["name"] | "Unknown";
    String      requesterMac  = doc["mac"] | "";
    if (requesterMac.length() == 0) return;  // ignore empty/spoofed
    // Already paired? Silently ignore repeat requests.
    String _cleanReq = requesterMac; _cleanReq.replace(":", "");
    if (isAlreadyPaired(_cleanReq)) return;
    // Don't interrupt if a pair dialog is already open.
    if (state == PAIR_REQUEST) return;
    strncpy(pendingPairName, requesterName, 15);
    pendingPairName[15] = '';
    pendingPairMac = requesterMac;
    state = PAIR_REQUEST;
  }

  // ── Pair accepted by the other Lodestone (we sent the request) ────────────
  String myCleanAcc = myMacStr; myCleanAcc.replace(":", "");
  if (t == "lodestone/accept/" + myCleanAcc) {
    String acceptorMac = doc["mac"] | "";
    const char* acceptorName = doc["name"] | "Device";
    if (acceptorMac.length() == 0) return;
    String cleanAcc = acceptorMac; cleanAcc.replace(":", "");
    if (!isAlreadyPaired(cleanAcc)) {
      addPairedDevice(cleanAcc);  // now THIS device stores the pair too
    }
    // Subscribe to the pair topic so we receive their position updates
    String pairTopicStr = "lodestone/pair/" + myCleanAcc + "_" + cleanAcc;
    mqtt.subscribe(pairTopicStr.c_str());
    pairTopicStr = "lodestone/pair/" + cleanAcc + "_" + myCleanAcc;
    mqtt.subscribe(pairTopicStr.c_str());
    // Show confirmation
    display.clearDisplay();
    display.setTextSize(1);
    display.setCursor(10, 20); display.print("Paired with:");
    display.setCursor(10, 34); display.print(acceptorName);
    display.display();
    delay(1500);
    return;
  }

  // ── Unpair request from app ──────────────────────────────────────────────
  String myCleanUp = myMacStr; myCleanUp.replace(":", "");
  if (t == "lodestone/unpair/" + myCleanUp) {
    const char* requesterName = doc["name"] | "App";
    // Remove this MAC from pairedMacs
    String requesterMac = doc["mac"] | "";
    requesterMac.replace(":", "");
    removePairedDevice(requesterMac);
    // Unsubscribe from pair topic
    String pairTopicStr = "lodestone/pair/" + myCleanUp + "_" + requesterMac;
    mqtt.unsubscribe(pairTopicStr.c_str());
    pairTopicStr = "lodestone/pair/" + requesterMac + "_" + myCleanUp;
    mqtt.unsubscribe(pairTopicStr.c_str());
    // Show brief notification
    display.clearDisplay();
    display.setTextSize(1);
    display.setCursor(0, 20); display.print("Unpaired by:");
    display.setCursor(0, 34); display.print(requesterName);
    display.display();
    delay(1500);
    return;
  }

  // ── Location request from app ────────────────────────────────────────────
  String myCleanLoc = myMacStr; myCleanLoc.replace(":", "");
  if (t == "lodestone/loc/request/" + myCleanLoc) {
    publishLocations();
    return;
  }

  // ── Incoming message ─────────────────────────────────────────────────────
  if (t.startsWith("lodestone/msg/")) {
    const char* sender = doc["from"] | "Unknown";
    const char* msgTxt = doc["msg"]  | "";
    // Paired-only: silently drop messages from unpaired senders.
    String _sm = doc["mac"] | "";
    _sm.replace(":", "");
    if (_sm.length() == 0 || !isAlreadyPaired(_sm)) return;
    // Shift inbox up, add new message
    if (inboxCount < 5) inboxCount++;
    for (int i = inboxCount-1; i > 0; i--)
      strncpy(inboxMsgs[i], inboxMsgs[i-1], 63);
    char combined[64];
    snprintf(combined, sizeof(combined), "%s: %s", sender, msgTxt);
    strncpy(inboxMsgs[0], combined, 63);
    // Flash notification on screen briefly if not already in MSG_INBOX
    if (state != MSG_INBOX && state != MSG_COMPOSE) {
      display.clearDisplay();
      display.setTextSize(1);
      display.setCursor(0, 0);  display.print("MSG from ");
      display.print(sender);
      display.setCursor(0, 16); display.print(msgTxt);
      display.display();
      delay(2000);
    }
  }

  // ── Location sync from app ────────────────────────────────────────────────
  if (t == "lodestone/locations") {
    String mac = doc["mac"] | "";
    JsonArray locs = doc["locations"].as<JsonArray>();
    if (locs.isNull()) return;
    locationCount = 0;
    for (JsonObject loc : locs) {
      if (locationCount >= 10) break;
      const char* n = loc["name"] | "";
      double la = loc["lat"] | 0.0;
      double lo = loc["lon"] | 0.0;
      strncpy(locations[locationCount].name, n, 15);
      locations[locationCount].lat = la;
      locations[locationCount].lon = lo;
      locationCount++;
    }
    saveLocations();
    display.clearDisplay();
    display.setTextSize(1);
    display.setCursor(10, 20); display.print("Locations synced");
    display.setCursor(10, 34); display.print("from app!");
    display.display();
    delay(1200);
  }
}

// =============================================================================
//  MQTT — connect / maintain
// =============================================================================
void connectMQTT() {
  if (!wifiConnected) return;
  wifiSecure.setInsecure();   // skip cert verify (fine for HiveMQ Cloud)
  mqtt.setServer(MQTT_HOST, MQTT_PORT);
  mqtt.setCallback(mqttCallback);
  mqtt.setBufferSize(512);
  mqtt.setKeepAlive(30);

  String clientId = "lodestone_" + myMacStr;
  clientId.replace(":", "");

  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(0, 0);  display.print("Connecting MQTT...");
  display.display();

  if (mqtt.connect(clientId.c_str(), MQTT_USER, MQTT_PASS)) {
    mqttConnected = true;
    // Subscribe to announce, pair requests, location sync
    mqtt.subscribe("lodestone/announce");
    mqtt.subscribe("lodestone/locations");
    String reqTopic = "lodestone/request/" + myMacStr;
    reqTopic.replace(":", "");
    mqtt.subscribe(reqTopic.c_str());
    String myClean = myMacStr; myClean.replace(":", "");
    String msgTopic = "lodestone/msg/" + myClean;
    mqtt.subscribe(msgTopic.c_str());
    // (global lodestone/msg/broadcast deliberately not subscribed — paired-only messaging)
    String myCleanUnpair = myMacStr; myCleanUnpair.replace(":", "");
    mqtt.subscribe(("lodestone/unpair/" + myCleanUnpair).c_str());
    String myCleanSub = myMacStr; myCleanSub.replace(":", "");
    mqtt.subscribe(("lodestone/loc/request/" + myCleanSub).c_str());
    // Subscribe to accept notifications so THIS device knows when its pair request was accepted
    String myCleanAcc = myMacStr; myCleanAcc.replace(":", "");
    mqtt.subscribe(("lodestone/accept/" + myCleanAcc).c_str());
    announcePresence();
    resubscribePaired();
    publishLocations();  // send stored locations to app
  }
}


// =============================================================================
//  MQTT — publish stored locations to app
// =============================================================================
void publishLocations() {
  if (!mqtt.connected()) return;
  // Build JSON array using snprintf — avoids quote escaping issues
  String json = "[";
  char locBuf[96];
  for (int i = 0; i < locationCount; i++) {
    if (i > 0) json += ",";
    snprintf(locBuf, sizeof(locBuf),
      "{\"name\":\"%s\",\"lat\":%.6f,\"lon\":%.6f}",
      locations[i].name,
      locations[i].lat,
      locations[i].lon);
    json += locBuf;
  }
  json += "]";
  String myClean = myMacStr; myClean.replace(":", "");
  String topic = "lodestone/loc/response/" + myClean;
  mqtt.publish(topic.c_str(), json.c_str(), true);
}

// =============================================================================
//  MQTT — announce presence
// =============================================================================
void announcePresence() {
  if (!mqtt.connected()) return;
  char annBuf[128];
  snprintf(annBuf, sizeof(annBuf), "{\"name\":\"%s\",\"mac\":\"%s\",\"type\":\"hardware\"}",
           deviceName, myMacStr.c_str());
  mqtt.publish("lodestone/announce", annBuf, true);
}

// =============================================================================
//  MQTT — broadcast GPS position to paired devices
// =============================================================================
void broadcastPosition() {
  if (!mqtt.connected()) return;
  if (!gps.location.isValid()) return;
  if (millis() - lastMqttSend < MQTT_INTERVAL) return;
  lastMqttSend = millis();

  StaticJsonDocument<256> doc;
  doc["name"]    = deviceName;
  doc["mac"]     = myMacStr;
  doc["lat"]     = gps.location.lat();
  doc["lon"]     = gps.location.lng();
  doc["heading"] = filteredHeading;
  doc["speed"]   = gps.speed.isValid() ? gps.speed.kmph() : 0.0;

  char buf[256];
  serializeJson(doc, buf);

  // Publish to a shared topic — app subscribes to lodestone/devices/<mac>
  String topic = "lodestone/devices/" + myMacStr;
  topic.replace(":", "");
  mqtt.publish(topic.c_str(), buf);

  // Also publish to each paired Lodestone's pair topic so they can track us.
  // The other device subscribes to lodestone/pair/<theirMac>_<ourMac>.
  String myClean = myMacStr; myClean.replace(":", "");
  for (int i = 0; i < pairedMacCount; i++) {
    String peerClean = String(pairedMacs[i]);
    String pairTopic = "lodestone/pair/" + peerClean + "_" + myClean;
    mqtt.publish(pairTopic.c_str(), buf);
  }
}

// =============================================================================
//  MQTT — receive positions (now handled in callback — stub kept for compat)
// =============================================================================
void receivePositions() { mqtt.loop(); }

// =============================================================================
//  Prune stale devices
// =============================================================================
void pruneDevices() {
  for (int i = 0; i < nearbyCount; i++) {
    if (millis() - nearbyDevices[i].lastSeen > 30000) {
      for (int j = i; j < nearbyCount - 1; j++)
        nearbyDevices[j] = nearbyDevices[j + 1];
      nearbyCount--;
      i--;
    }
  }
}

// =============================================================================
//  DRAW HELPERS
// =============================================================================

// ─── Status bar time (top-right, every screen) ────────────────────────────────
// Draw WiFi signal bars at given x position, y=0 row
void drawWiFiBars(int x) {
  if (!wifiConnected) return;
  int rssi = WiFi.RSSI();
  int bars = 0;
  if      (rssi >= -55) bars = 3;
  else if (rssi >= -70) bars = 2;
  else if (rssi >= -85) bars = 1;
  for (int b = 0; b < 3; b++) {
    int bx = x + b * 6;
    int bh = 2 + b * 2;
    if (b < bars) display.fillRect(bx, 7 - bh, 4, bh, WHITE);
    else          display.drawRect(bx, 7 - bh, 4, bh, WHITE);
  }
}

void drawStatusTime() {
  // Time only — no WiFi bars here (bars shown on main menu only)
  if (!gps.time.isValid()) return;
  int totalMin = gps.time.hour() * 60 + gps.time.minute() + 330;
  totalMin %= (24 * 60);
  if (totalMin < 0) totalMin += 24 * 60;
  char buf[6];
  snprintf(buf, sizeof(buf), "%02d:%02d", totalMin / 60, totalMin % 60);
  display.setTextSize(1);
  display.setCursor(98, 0);
  display.print(buf);
}

void drawMainMenu() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);

  // Header: title left | wifi bars centre | time right | separator
  display.setCursor(0, 0);
  display.print("LODESTONE");
  drawWiFiBars(68);   // bars between title and time, x=68..90
  drawStatusTime();   // time at x=98
  display.drawLine(0, 9, 127, 9, WHITE);

  // Scrollable list — 4 rows visible, 13px each, starting at y=12
  const int totalItems  = 6;   // now includes SPEEDOMETER
  const int visibleRows = 4;
  int startItem = 0;
  if (menuIndex >= visibleRows) startItem = menuIndex - visibleRows + 1;

  for (int i = 0; i < visibleRows; i++) {
    int item = startItem + i;
    if (item >= totalItems) break;
    display.setCursor(0, 12 + i * 13);
    display.print(item == menuIndex ? "> " : "  ");
    display.print(menuItems[item]);
  }

  display.display();
}

void drawDirFinderMenu() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("DIRECTION FINDER");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  for (int i = 0; i < 3; i++) {
    display.setCursor(0, 14 + i * 14);
    display.print(i == menuIndex ? "> " : "  ");
    display.print(dirFinderItems[i]);
  }
  display.display();
}

void drawDeviceTrackerMenu() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("DEVICE TRACKER");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  for (int i = 0; i < 4; i++) {
    display.setCursor(0, 13 + i * 12);
    display.print(i == menuIndex ? "> " : "  ");
    display.print(deviceTrackerItems[i]);
    if (i == 3) { display.print(" ("); display.print(inboxCount); display.print(")"); }
  }
  display.display();
}

void drawLocationList(const char* title) {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0);
  display.print(title);
  drawStatusTime();
  if (locationCount == 0) {
    display.setCursor(0, 20);
    display.print("(none saved)");
  }
  for (int i = 0; i < locationCount; i++) {
    display.setCursor(0, 12 + i * 10);
    display.print(i == menuIndex ? "> " : "  ");
    display.print(locations[i].name);
  }
  display.display();
}

void drawDeleteConfirm(const char* locName) {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0);  display.print("DELETE LOCATION?");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  display.setCursor(0, 18); display.print(locName);
  display.setCursor(0, 34); display.print("This cannot be undone");
  display.display();
}

void drawSaveConfirm() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("SAVE LOCATION?");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  display.setCursor(14, 16); display.print(inputName);
  display.setCursor(0,  28); display.print("Lat: "); display.print(tempLat, 5);
  display.setCursor(0,  38); display.print("Lon: "); display.print(tempLon, 5);
  display.display();
}

void drawSaveError() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("CANNOT SAVE");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  display.setCursor(0, 18); display.print(saveErrorMsg);
  display.display();
}

void drawNameInput() {
  display.clearDisplay();
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  // Show entered name with cursor block
  display.setCursor(0, 14);
  display.print(inputName);
  display.print("_");
  // Selected character — large and centred
  display.setTextSize(2);
  char selChar[2] = { nameChars[charIndex], 0 };
  int cx = (128 - 12) / 2;
  display.setCursor(cx, 28);
  display.print(selChar);
  display.setTextSize(1);
  display.display();
}

void drawCoordInput(const char* title) {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print(title);
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  display.setCursor(0, 14);
  display.print(coordInput);
  display.print("_");
  display.setTextSize(2);
  char selChar[2] = { numChars[numIndex], 0 };
  int cx = (128 - 12) / 2;
  display.setCursor(cx, 28);
  display.print(selChar);
  display.setTextSize(1);
  display.display();
}

void drawWiFiScan() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("Select Network:");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);

  // Scrollable: 4 rows visible, 13px each starting at y=12
  const int visRows = 4;
  int startNet = 0;
  if (networkIndex >= visRows) startNet = networkIndex - visRows + 1;

  for (int i = 0; i < visRows; i++) {
    int idx = startNet + i;
    if (idx >= networkCount) break;
    int y = 12 + i * 13;
    display.setCursor(0, y);
    display.print(idx == networkIndex ? "> " : "  ");
    String ssid = scannedSSIDs[idx];
    if (ssid.length() > 14) ssid = ssid.substring(0, 14);
    display.print(ssid);
    // Signal strength bars (3 bars, rightmost 18px)
    int rssi = scannedRSSI[idx];
    int bars = 0;
    if      (rssi >= -55) bars = 3;
    else if (rssi >= -70) bars = 2;
    else if (rssi >= -85) bars = 1;
    for (int b = 0; b < 3; b++) {
      int bx = 110 + b * 6;
      int bh = 3 + b * 3;
      if (b < bars) display.fillRect(bx, y + 8 - bh, 4, bh, WHITE);
      else          display.drawRect(bx, y + 8 - bh, 4, bh, WHITE);
    }
  }
  // (scroll indicator removed)
  display.display();
}

void drawWiFiTypeSelect() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0);  display.print("SELECT NETWORK TYPE");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  display.setCursor(0, 16); display.print(menuIndex == 0 ? "> " : "  ");
  display.print("Personal (WPA2)");
  display.setCursor(0, 30); display.print(menuIndex == 1 ? "> " : "  ");
  display.print("Enterprise (LDAP)");
  display.display();
}

void drawTextInput(const char* title, const String& currentText, bool isPassword) {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print(title);
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);

  String shown = "";
  if (isPassword) {
    for (int i = 0; i < (int)currentText.length(); i++) shown += "*";
  } else {
    shown = currentText;
  }
  display.setCursor(0, 12); display.print(shown); display.print("_");

  // Current char — large, centred
  display.setTextSize(2);
  int len = getCurrentCharsLen();
  bool isDone = (activeSet == SPECIAL && charIndex >= len);
  if (isDone) {
    display.setCursor(30, 26); display.print("SAVE");
  } else {
    char selChar[2] = { getCurrentChars()[charIndex], 0 };
    int cx = (128 - 12) / 2;
    display.setCursor(cx, 26);
    display.print(selChar);
  }
  display.setTextSize(1);

  // Charset indicator top-right
  display.setCursor(96, 12);
  switch (activeSet) {
    case CAPS:    display.print("[ABC]"); break;
    case LOWER:   display.print("[abc]"); break;
    case DIGITS:  display.print("[123]"); break;
    case SPECIAL: display.print("[!@#]"); break;
  }

  display.display();
}


void drawSettingsMenu() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("SETTINGS");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  // 5 items, 10px rows, y=12..62. Compact: no sub-lines.
  for (int i = 0; i < 5; i++) {
    int y = 12 + i * 10;
    display.setCursor(0, y);
    display.print(i == menuIndex ? "> " : "  ");
    if (i == 1 && !wifiConnected) {
      display.print("["); display.print(settingsItems[i]); display.print("]");
    } else if (i == 2) {
      display.print("NAME:");
      char tn[10]; strncpy(tn, deviceName, 9); tn[9]='\0';
      display.print(tn);
    } else if (i == 4) {
      display.print(settingsItems[i]);
      display.print(":");
      if (sleepTimeoutMin == 0) display.print("Off");
      else { display.print(sleepTimeoutMin); display.print("m"); }
    } else {
      display.print(settingsItems[i]);
    }
  }
  display.display();
}

void drawSleepSet() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("SLEEP TIMEOUT");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  const uint8_t opts[] = {0, 1, 2, 5};
  for (int i = 0; i < 4; i++) {
    display.setCursor(0, 18 + i * 12);
    display.print(i == menuIndex ? "> " : "  ");
    if (opts[i] == 0) display.print("Never");
    else { display.print(opts[i]); display.print(" minute"); if(opts[i]>1) display.print("s"); }
    if (opts[i] == sleepTimeoutMin) display.print(" *");
  }
  display.display();
}

void drawPairLodestone() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("PAIR LODESTONE");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  if (!wifiConnected) {
    display.setCursor(0, 20); display.print("WiFi not connected!");
    display.display(); return;
  }
  int row = 0;
  for (int i = 0; i < nearbyCount && row < 4; i++) {
    if (!nearbyDevices[i].isHardware) continue;
    if (isNearbyDevicePaired(i)) continue;  // show only UNpaired
    display.setCursor(0, 13 + row * 12);
    display.print(row == menuIndex ? "> " : "  ");
    display.print(nearbyDevices[i].name);
    row++;
  }
  if (row == 0) {
    display.setCursor(0, 22); display.print("No unpaired nearby");
    display.setCursor(0, 34); display.print("Lodestones found");
  } else {
    display.setCursor(0, 56); display.print("PRESS to request");
  }
  display.display();
}

void drawDeviceTracker() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  if (!wifiConnected) {
    display.setCursor(0, 0);  display.print("WiFi not connected!");
    display.setCursor(0, 16); display.print("Go to WiFi Setup");
    display.display(); return;
  }
  // Count paired hw
  int pc = 0;
  for (int i = 0; i < nearbyCount; i++) if (isNearbyDevicePaired(i)) pc++;
  display.setCursor(0, 0); display.print("TRACK ("); display.print(pc); display.print(")");
  drawStatusTime();
  display.drawLine(0, 10, 127, 10, WHITE);
  if (pc == 0) {
    display.setCursor(0, 22); display.print("No paired Lodestones");
    display.setCursor(0, 34); display.print("Use PAIR LODESTONE");
    display.setCursor(0, 46); display.print("from the menu.");
    display.display(); return;
  }
  int row = 0;
  for (int i = 0; i < nearbyCount && row < 4; i++) {
    if (!isNearbyDevicePaired(i)) continue;
    display.setCursor(0, 13 + row * 11);
    display.print(row == menuIndex ? "> " : "  ");
    char nm[11]; strncpy(nm, nearbyDevices[i].name, 10); nm[10]='\0';
    display.print(nm);
    unsigned long age = (millis() - nearbyDevices[i].lastSeen) / 1000;
    display.setCursor(96, 13 + row * 11);
    display.print(age); display.print("s");
    row++;
  }
  display.setCursor(0, 57); display.print(">PRESS  RIGHT:unpair");
  display.display();
}

// =============================================================================
//  REL ANGLE → FRAME INDEX
// =============================================================================
int relToFrame(float rel) {
  float a = 180.0f - rel;
  int f = (int)(a / 360.0f * FRAME_COUNT);
  f = (f + FRAME_OFFSET) % FRAME_COUNT;
  return f;
}

// Circular EMA — blends two angles correctly across the 0/360 boundary
static float circularEMA(float filtered, float newVal, float alpha) {
  float fRad = filtered * (PI / 180.0f);
  float nRad = newVal   * (PI / 180.0f);
  float s = (1.0f - alpha) * sinf(fRad) + alpha * sinf(nRad);
  float c = (1.0f - alpha) * cosf(fRad) + alpha * cosf(nRad);
  float r = atan2f(s, c) * (180.0f / PI);
  if (r < 0.0f) r += 360.0f;
  return r;
}

// =============================================================================
//  DIRECTION LABEL
// =============================================================================
String getDirection(float heading) {
  if      (heading >= 337.5 || heading < 22.5)  return "N";
  else if (heading >= 22.5  && heading < 67.5)  return "NE";
  else if (heading >= 67.5  && heading < 112.5) return "E";
  else if (heading >= 112.5 && heading < 157.5) return "SE";
  else if (heading >= 157.5 && heading < 202.5) return "S";
  else if (heading >= 202.5 && heading < 247.5) return "SW";
  else if (heading >= 247.5 && heading < 292.5) return "W";
  else                                           return "NW";
}

// =============================================================================
//  NAVIGATION SCREEN
// =============================================================================

// Format GPS time as HH:MM from TinyGPS
static void printGpsTime() {
  if (!gps.time.isValid()) { display.print("--:--"); return; }
  // Convert UTC to IST (UTC+5:30)
  int totalMin = gps.time.hour() * 60 + gps.time.minute() + 330;
  totalMin %= (24 * 60);
  if (totalMin < 0) totalMin += 24 * 60;
  char buf[6];
  snprintf(buf, sizeof(buf), "%02d:%02d", totalMin / 60, totalMin % 60);
  display.print(buf);
}

void runNavigation() {
  float hdg = getHeading();
  float roll, pitch;
  getTilt(roll, pitch);
  bool tiltWarn = (fabsf(roll) > TILT_WARN_DEG || fabsf(pitch) > TILT_WARN_DEG);

  while (GPS_SERIAL.available()) gps.encode(GPS_SERIAL.read());

  if (!gps.location.isValid()) {
    display.clearDisplay();
    display.setTextSize(1);
    display.setCursor(22, 0);  display.print("Acquiring GPS");
    display.setCursor(10, 14); display.print("Please wait...");
    // Animated dots
    static uint8_t dots = 0;
    static unsigned long lastDot = 0;
    if (millis() - lastDot > 500) { dots = (dots + 1) % 4; lastDot = millis(); }
    display.setCursor(10, 28);
    for (uint8_t i = 0; i < dots; i++) display.print(".");
    if (tiltWarn) { display.setCursor(20, 54); display.print("!! TILT !!"); }
    display.display();
    if (btnPressed(BTN_LEFT)) { state = MAIN_MENU; menuIndex = 0; }
    return;
  }

  float rawBrg  = (float)TinyGPSPlus::courseTo(
                    gps.location.lat(), gps.location.lng(), TARGET_LAT, TARGET_LON);
  float rawDist = (float)TinyGPSPlus::distanceBetween(
                    gps.location.lat(), gps.location.lng(), TARGET_LAT, TARGET_LON);

  if (smoothBearing < 0.0f) { smoothBearing = rawBrg; smoothDist = rawDist; }

  smoothBearing = circularEMA(smoothBearing, rawBrg, 0.25f);
  smoothDist    = 0.75f * smoothDist + 0.25f * rawDist;

  float rawRel = smoothBearing - hdg;
  if (rawRel >  180.0f) rawRel -= 360.0f;
  if (rawRel < -180.0f) rawRel += 360.0f;

  float relFor360 = rawRel + 180.0f;
  float sfFor360  = smoothRelAngle + 180.0f;
  sfFor360 = circularEMA(sfFor360, relFor360, 0.25f);
  smoothRelAngle = sfFor360 - 180.0f;

  int frame = relToFrame(smoothRelAngle);
  int relDeg = (int)smoothRelAngle;

  display.clearDisplay();
  display.setTextSize(1);

  // ── Row 0 (y=0): target name centered — OR tilt warning ───────────────────
  if (tiltWarn) {
    display.setCursor(0, 0); display.print("!! TILT !!");
  } else {
    int nameLen = strlen(TARGET_NAME);
    int nameX = (128 - nameLen * 6) / 2;
    if (nameX < 0) nameX = 0;
    display.setCursor(nameX, 0);
    display.print(TARGET_NAME);
  }

  // ── Arrow centered horizontally, y=8..55 (48px, no overlap) ──────────────
  // x = (128 - 48) / 2 = 40
  display.drawBitmap(40, 8, frames[frame], FRAME_WIDTH, FRAME_HEIGHT, WHITE);

  // ── Bottom row (y=56): angle LEFT | distance RIGHT ─────────────────────────
  // Angle
  display.setCursor(0, 56);
  if (relDeg == 0) {
    display.print("ON TARGET");
  } else {
    if (relDeg > 0) display.print("+");
    display.print(relDeg);
    display.print((char)247);
    if      (abs(relDeg) <= 45)  display.print(relDeg > 0 ? " slR" : " slL");
    else if (abs(relDeg) <= 135) display.print(relDeg > 0 ? " R"   : " L");
    else                         display.print(relDeg > 0 ? " bkR" : " bkL");
  }
  // Distance right-aligned
  char distBuf[10];
  if (smoothDist >= 1000.0f)
    snprintf(distBuf, sizeof(distBuf), "%.1fkm", smoothDist / 1000.0f);
  else
    snprintf(distBuf, sizeof(distBuf), "%dm", (int)smoothDist);
  int distX = 127 - (int)strlen(distBuf) * 6;
  display.setCursor(distX, 56);
  display.print(distBuf);

  display.display();
  if (btnPressed(BTN_LEFT)) {
    smoothBearing = -1.0f;
    state = MAIN_MENU; menuIndex = 0;
  }
}

// =============================================================================
//  DIGITAL COMPASS SCREEN
// =============================================================================
void runDigitalCompass() {
  float hdg = getHeading();
  float roll, pitch;
  getTilt(roll, pitch);
  bool tiltWarn = (fabsf(roll) > TILT_WARN_DEG || fabsf(pitch) > TILT_WARN_DEG);

  display.clearDisplay();

  // ── Status bar: wifi bars + time at y=0, separator at y=9 ─────────────────
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);

  // ── Heading: textSize(2) to avoid overlapping status bar ──────────────────
  // textSize(2) = 12px wide × 16px tall per char — fits cleanly below y=9
  display.setTextSize(2);
  {
    char hdgBuf[4];
    snprintf(hdgBuf, sizeof(hdgBuf), "%03d", (int)hdg);
    // 3 digits + degree: 3×12 + 10 = 46px wide
    int hdgW = 3 * 12 + 10;
    int hdgX = (128 - hdgW) / 2;
    display.setCursor(hdgX, 12);
    display.print(hdgBuf);
    display.setTextSize(1);
    display.print((char)247);   // small degree symbol avoids extra height
  }

  // ── Direction label: textSize(2) centered below heading ───────────────────
  display.setTextSize(2);
  String dir = getDirection(hdg);
  int dirX = (128 - (int)dir.length() * 12) / 2;
  display.setCursor(dirX, 36);
  display.print(dir);

  // ── Tilt warning at bottom ────────────────────────────────────────────────
  if (tiltWarn) {
    display.setTextSize(1);
    display.setCursor(0, 56);
    display.print("!! TILT !!");
  }
  display.display();
  if (btnPressed(BTN_LEFT)) { state = MAIN_MENU; menuIndex = 0; }
}

// =============================================================================
//  DEVICE TRACKING SCREEN
// =============================================================================
void runDeviceTracking() {
  // MQTT handled in main loop
  pruneDevices();

  float hdg = getHeading();
  float roll, pitch;
  getTilt(roll, pitch);
  bool tiltWarn = (fabsf(roll) > TILT_WARN_DEG || fabsf(pitch) > TILT_WARN_DEG);

  while (GPS_SERIAL.available()) gps.encode(GPS_SERIAL.read());

  if (selectedDevice >= nearbyCount) {
    display.clearDisplay();
    display.setTextSize(1);
    display.setCursor(0, 20); display.print("Device lost!");
    display.setCursor(0, 32); display.print("Signal timeout");
    display.display();
    delay(2000);
    smoothBearing = -1.0f;
    state = DEVICE_TRACKER; menuIndex = 0;
    return;
  }

  DiscoveredDevice& dev = nearbyDevices[selectedDevice];

  if (!gps.location.isValid()) {
    display.clearDisplay();
    display.setTextSize(1);
    display.setCursor(0, 0);  display.print("GPS: searching...");
    display.setCursor(0, 12); display.print("HDG: "); display.print(hdg, 1);
    display.setCursor(0, 24); display.print("TGT: "); display.print(dev.name);
    if (tiltWarn) { display.setCursor(0, 50); display.print("!! TILT !!"); }
    display.display();
    if (btnPressed(BTN_LEFT)) { smoothBearing = -1.0f; state = DEVICE_TRACKER; menuIndex = 0; }
    return;
  }

  // Wait until we have a real position from the target device
  if (dev.lat == 0.0 && dev.lon == 0.0) {
    display.clearDisplay();
    display.setTextSize(1);
    display.setCursor(0, 0);  display.print(dev.name);
    display.setCursor(0, 14); display.print("Waiting for their");
    display.setCursor(0, 26); display.print("GPS position...");
    display.setCursor(0, 40); display.print("(They need GPS fix)");
    if (tiltWarn) { display.setCursor(0, 54); display.print("!! TILT !!"); }
    display.display();
    if (btnPressed(BTN_LEFT)) { smoothBearing = -1.0f; state = DEVICE_TRACKER; menuIndex = 0; }
    return;
  }

  float rawBrg  = (float)TinyGPSPlus::courseTo(
                    gps.location.lat(), gps.location.lng(), dev.lat, dev.lon);
  float rawDist = (float)TinyGPSPlus::distanceBetween(
                    gps.location.lat(), gps.location.lng(), dev.lat, dev.lon);

  if (smoothBearing < 0.0f) { smoothBearing = rawBrg; smoothDist = rawDist; }

  smoothBearing = circularEMA(smoothBearing, rawBrg, 0.25f);
  smoothDist    = 0.75f * smoothDist + 0.25f * rawDist;

  float rawRel = smoothBearing - hdg;
  if (rawRel >  180.0f) rawRel -= 360.0f;
  if (rawRel < -180.0f) rawRel += 360.0f;

  float relFor360 = rawRel + 180.0f;
  float sfFor360  = smoothRelAngle + 180.0f;
  sfFor360 = circularEMA(sfFor360, relFor360, 0.25f);
  smoothRelAngle = sfFor360 - 180.0f;

  int frame = relToFrame(smoothRelAngle);

  display.clearDisplay();
  display.drawBitmap(42, 0, frames[frame], FRAME_WIDTH, FRAME_HEIGHT, WHITE);
  display.setTextSize(1);
  display.setCursor(0, 0);  display.print(dev.name);
  display.setCursor(0, 10);
  if (smoothRelAngle >= 0) display.print("+");
  display.print((int)smoothRelAngle); display.print((char)247);
  display.setCursor(0, 50);
  display.print("DST ");
  if (smoothDist >= 1000) { display.print(smoothDist / 1000.0f, 2); display.print("km"); }
  else                    { display.print((int)smoothDist);          display.print("m");  }
  display.setCursor(0, 58);
  display.print("BRG "); display.print((int)smoothBearing); display.print((char)247);
  if (tiltWarn) {
    display.fillRect(0, 18, 38, 10, BLACK);
    display.setCursor(0, 20); display.print("TILT!");
  }
  display.display();
  if (btnPressed(BTN_LEFT)) { smoothBearing = -1.0f; state = DEVICE_TRACKER; menuIndex = 0; }
}



// =============================================================================
//  SPEEDOMETER SCREEN
// =============================================================================
void runSpeedometer() {
  while (GPS_SERIAL.available()) gps.encode(GPS_SERIAL.read());

  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("SPEEDOMETER");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);

  if (!gps.speed.isValid() || !gps.location.isValid()) {
    display.setCursor(10, 28); display.print("Acquiring GPS...");
    display.display();
    if (btnPressed(BTN_LEFT)) { state = MAIN_MENU; menuIndex = 0; }
    return;
  }

  float speedKmh = (float)gps.speed.kmph();

  // Large speed number — textSize(3) centred, y=14
  display.setTextSize(3);
  char spdbuf[6];
  if (speedKmh >= 100.0f)
    snprintf(spdbuf, sizeof(spdbuf), "%3d", (int)speedKmh);
  else
    snprintf(spdbuf, sizeof(spdbuf), "%4.1f", speedKmh);
  int sw = strlen(spdbuf) * 18;
  display.setCursor((128 - sw) / 2, 14);
  display.print(spdbuf);

  // Unit label "km/h" small, centred below number
  display.setTextSize(1);
  display.setCursor(50, 42);
  display.print("km/h");

  // GPS satellite count bottom-left, accuracy bottom-right
  display.setCursor(0, 56);
  display.print("SAT:");
  display.print(gps.satellites.isValid() ? (int)gps.satellites.value() : 0);

  // Course (direction of travel) bottom-right
  if (gps.course.isValid()) {
    display.setCursor(74, 56);
    display.print("HDG:");
    display.print((int)gps.course.deg());
    display.print((char)247);
  }

  display.display();
  if (btnPressed(BTN_LEFT)) { state = MAIN_MENU; menuIndex = 0; }
}


// =============================================================================
//  PAIR REQUEST SCREEN
// =============================================================================
void drawPairRequest() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("PAIR REQUEST");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  display.setCursor(0, 14); display.print("Connect with:");
  display.setTextSize(1);
  display.setCursor(0, 26); display.print(pendingPairName);
  display.setCursor(0, 42); display.print("Press to ACCEPT");
  display.setCursor(0, 54); display.print("Left to DECLINE");
  display.display();
}


// =============================================================================
//  CONNECT APP SCREEN — show nearby app clients, send pair request
// =============================================================================
void drawConnectApp() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("CONNECT APP");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  // Prune stale app clients
  for (int i = 0; i < appClientCount; i++) {
    if (millis() - appClients[i].lastSeen > 30000) {
      for (int j = i; j < appClientCount-1; j++) appClients[j] = appClients[j+1];
      appClientCount--; i--;
    }
  }
  if (appClientCount == 0) {
    display.setCursor(0, 24); display.print("No app users found");
    display.setCursor(0, 36); display.print("Open Lodestone app");
  } else {
    for (int i = 0; i < appClientCount && i < 4; i++) {
      display.setCursor(0, 14 + i * 12);
      display.print(i == menuIndex ? "> " : "  ");
      display.print(appClients[i].name);
    }
  }
  display.display();
}

// =============================================================================
//  MSG INBOX SCREEN
// =============================================================================
void drawMsgInbox() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("MESSAGES");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  if (inboxCount == 0) {
    display.setCursor(0, 28); display.print("No messages yet");
  } else {
    for (int i = 0; i < inboxCount && i < 4; i++) {
      display.setCursor(0, 13 + i * 12);
      // Truncate to fit screen
      char truncated[22];
      strncpy(truncated, inboxMsgs[i], 21);
      truncated[21] = '\0';
      display.print(truncated);
    }
  }
  display.setCursor(0, 56); display.print("Press: New message");
  display.display();
}

// =============================================================================
//  MSG COMPOSE SCREEN — type a short message with the rocker
// =============================================================================
void drawMsgCompose() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("TO: ");
  if (msgTarget == -1) display.print("ALL PAIRED");
  else if (msgTarget < appClientCount) display.print(appClients[msgTarget].name);
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  display.setCursor(0, 13); display.print(composeMsg); display.print("_");
  // Show current char large
  display.setTextSize(2);
  char selChar[2] = { nameChars[charIndex], 0 };
  display.setCursor(54, 28);
  display.print(selChar);
  display.setTextSize(1);
  display.setCursor(0, 48); display.print("Len: "); display.print(composeMsgLen);
  display.setCursor(0, 56); display.print("Right=Send Left=Del");
  display.display();
}


// ─── Paired devices EEPROM ────────────────────────────────────────────────────
// Stores MAC strings of paired devices so pairing survives reboot
// pairedMacs/pairedMacCount declared in global section above

void savePairedDevices() {
  EEPROM.write(PAIRED_EEPROM_ADDR, (uint8_t)pairedMacCount);
  for (int i = 0; i < 10; i++) {
    int addr = PAIRED_EEPROM_ADDR + 1 + i * 20;
    for (int j = 0; j < 20; j++)
      EEPROM.write(addr + j, (uint8_t)(i < pairedMacCount ? pairedMacs[i][j] : 0));
  }
  EEPROM.commit();
}

void loadPairedDevices() {
  pairedMacCount = EEPROM.read(PAIRED_EEPROM_ADDR);
  if (pairedMacCount > 10) pairedMacCount = 0;
  for (int i = 0; i < pairedMacCount; i++) {
    int addr = PAIRED_EEPROM_ADDR + 1 + i * 20;
    for (int j = 0; j < 19; j++)
      pairedMacs[i][j] = (char)EEPROM.read(addr + j);
    pairedMacs[i][19] = '';
  }
}

bool isAlreadyPaired(const String& mac) {
  for (int i = 0; i < pairedMacCount; i++)
    if (mac == String(pairedMacs[i])) return true;
  return false;
}

// True if the given nearbyDevices[] entry is a paired hardware Lodestone.
bool isNearbyDevicePaired(int idx) {
  if (idx < 0 || idx >= nearbyCount) return false;
  if (!nearbyDevices[idx].isHardware) return false;
  char mc[20];
  snprintf(mc, sizeof(mc), "%02X%02X%02X%02X%02X%02X",
    nearbyDevices[idx].mac[0],nearbyDevices[idx].mac[1],nearbyDevices[idx].mac[2],
    nearbyDevices[idx].mac[3],nearbyDevices[idx].mac[4],nearbyDevices[idx].mac[5]);
  return isAlreadyPaired(String(mc));
}

void addPairedDevice(const String& mac) {
  if (isAlreadyPaired(mac) || pairedMacCount >= 10) return;
  strncpy(pairedMacs[pairedMacCount], mac.c_str(), 19);
  pairedMacs[pairedMacCount][19] = '';
  pairedMacCount++;
  savePairedDevices();
}

void removePairedDevice(const String& mac) {
  for (int i = 0; i < pairedMacCount; i++) {
    if (mac == String(pairedMacs[i])) {
      for (int j = i; j < pairedMacCount-1; j++)
        strncpy(pairedMacs[j], pairedMacs[j+1], 19);
      pairedMacCount--;
      savePairedDevices();
      return;
    }
  }
}

// Re-subscribe to all previously paired device topics
void resubscribePaired() {
  for (int i = 0; i < pairedMacCount; i++) {
    String mac = String(pairedMacs[i]);
    mac.replace(":", "");
    String myClean = myMacStr; myClean.replace(":", "");
    String combined = myClean + "_" + mac;
    mqtt.subscribe(("lodestone/pair/" + combined).c_str());
  }
}


// =============================================================================
//  MSG TARGET SELECT — choose who to send message to
// =============================================================================
void drawMsgTargetSelect() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0); display.print("SEND TO:");
  drawStatusTime();
  display.drawLine(0, 9, 127, 9, WHITE);
  int row = 0;
  // Option 0: Broadcast to all paired
  display.setCursor(0, 13 + row*11);
  display.print(menuIndex == 0 ? "> " : "  ");
  display.print("ALL PAIRED");
  row++;
  // Option 1..appClientCount: individual app clients (paired only)
  int optIdx = 1;
  for (int i = 0; i < appClientCount && row < 5; i++) {
    String cm = String(appClients[i].mac); cm.replace(":","");
    if (!isAlreadyPaired(cm)) { optIdx++; continue; }
    display.setCursor(0, 13 + row*11);
    display.print(menuIndex == optIdx ? "> " : "  ");
    display.print("A:"); display.print(appClients[i].name);
    row++; optIdx++;
  }
  // After app clients: paired hardware Lodestones
  for (int i = 0; i < nearbyCount && row < 5; i++) {
    if (!isNearbyDevicePaired(i)) continue;
    display.setCursor(0, 13 + row*11);
    display.print(menuIndex == optIdx ? "> " : "  ");
    display.print("L:"); display.print(nearbyDevices[i].name);
    row++; optIdx++;
  }
  display.display();
}

// =============================================================================
//  SETUP
// =============================================================================
void setup() {
  Serial.begin(115200);
  GPS_SERIAL.begin(9600, SERIAL_8N1, 16, 17);
  Wire.begin(21, 22);
  EEPROM.begin(EEPROM_SIZE);

  pinMode(BTN_UP,    INPUT_PULLUP);
  pinMode(BTN_DOWN,  INPUT_PULLUP);
  pinMode(BTN_LEFT,  INPUT_PULLUP);
  pinMode(BTN_RIGHT, INPUT_PULLUP);
  pinMode(BTN_PRESS, INPUT_PULLUP);

  display.begin(SCREEN_ADDRESS, true);
  display.setTextColor(WHITE);
  display.clearDisplay();
  display.setTextSize(2);
  display.setCursor(10, 20);
  display.print("Lodestone");
  display.display();
  delay(2000);

  writeReg(LSM303_ACCEL_ADDR, 0x20, 0x27);
  writeReg(LSM303_MAG_ADDR,   0x00, 0x14);
  writeReg(LSM303_MAG_ADDR,   0x01, 0x20);
  writeReg(LSM303_MAG_ADDR,   0x02, 0x00);
  delay(100);

  loadLocations();
  loadWiFiNetworks();
  loadSettings();
  loadPairedDevices();
  if (savedNetworkCount > 0) autoConnectWiFi();
  myMacStr = WiFi.macAddress();
  if (wifiConnected) connectMQTT();

  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(10, 24);
  display.print("Ready.");
  display.display();
  delay(800);
  resetActivity();
}

// =============================================================================
//  LOOP
// =============================================================================
void loop() {

  checkSleep();
  // Wake on any button
  if (!digitalRead(BTN_UP)||!digitalRead(BTN_DOWN)||
      !digitalRead(BTN_LEFT)||!digitalRead(BTN_RIGHT)||
      !digitalRead(BTN_PRESS)) resetActivity();

  if (displaySleeping) { delay(100); return; }

  // ── MQTT maintain ──────────────────────────────────────────────────────────
  if (wifiConnected) {
    if (!mqtt.connected()) {
      static unsigned long lastMqttRetry = 0;
      if (millis() - lastMqttRetry > 10000) {
        lastMqttRetry = millis();
        connectMQTT();
      }
    } else {
      mqttConnected = true;
      mqtt.loop();
      broadcastPosition();
      pruneDevices();
      // Announce every 30 s
      if (millis() - lastAnnounce > 30000) {
        lastAnnounce = millis();
        announcePresence();
      }
    }
  }

  while (GPS_SERIAL.available()) gps.encode(GPS_SERIAL.read());

  // ── MAIN MENU ──────────────────────────────────────────────────────────────
  if (state == MAIN_MENU) {
    drawMainMenu();
    if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = 5; }
    if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex > 5) menuIndex = 0; }
    if (btnPressed(BTN_PRESS)) {
      if (menuIndex == 0) { state = DIR_FINDER_MENU;     menuIndex = 0; }
      if (menuIndex == 1) { state = COMPASS; }
      if (menuIndex == 2) { state = DEVICE_TRACKER_MENU; menuIndex = 0; }
      if (menuIndex == 3) { runCalibration(); }
      if (menuIndex == 4) { state = SPEEDOMETER; }
      if (menuIndex == 5) { state = SETTINGS_MENU; menuIndex = 0; }
    }
  }

  // ── DIRECTION FINDER MENU ──────────────────────────────────────────────────
  else if (state == DIR_FINDER_MENU) {
    drawDirFinderMenu();
    if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = 2; }
    if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex > 2) menuIndex = 0; }
    if (btnPressed(BTN_PRESS)) {
      if (menuIndex == 0) { state = SELECT_COORD;    menuIndex = 0; }
      if (menuIndex == 1) { state = KEYPAD_NAME;     inputName = ""; charIndex = 0; }
      if (menuIndex == 2) { state = DELETE_LOCATION; menuIndex = 0; }
    }
    if (btnPressed(BTN_LEFT)) { state = MAIN_MENU; menuIndex = 0; }
  }

  // ── DEVICE TRACKER MENU ────────────────────────────────────────────────────
  else if (state == DEVICE_TRACKER_MENU) {
    drawDeviceTrackerMenu();
    if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = 3; }
    if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex > 3) menuIndex = 0; }
    if (btnPressed(BTN_PRESS)) {
      if (menuIndex == 0) { state = DEVICE_TRACKER;  menuIndex = 0; }
      if (menuIndex == 1) { state = PAIR_LODESTONE;  menuIndex = 0; }
      if (menuIndex == 2) { state = CONNECT_APP;     menuIndex = 0; }
      if (menuIndex == 3) { state = MSG_INBOX;       menuIndex = 0; }
    }
    if (btnPressed(BTN_LEFT)) { state = MAIN_MENU; menuIndex = 0; }
  }

  // ── SELECT COORD ───────────────────────────────────────────────────────────
  else if (state == SELECT_COORD) {
    drawLocationList("SELECT TARGET");
    if (locationCount == 0) {
      if (btnPressed(BTN_LEFT)) { state = DIR_FINDER_MENU; menuIndex = 0; }
      return;
    }
    if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = locationCount - 1; }
    if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex >= locationCount) menuIndex = 0; }
    if (btnPressed(BTN_PRESS)) {
      TARGET_LAT = locations[menuIndex].lat;
      TARGET_LON = locations[menuIndex].lon;
      strncpy(TARGET_NAME, locations[menuIndex].name, 15);
      TARGET_NAME[15] = '\0';
      navActive  = true;
      state      = NAVIGATING;
    }
    if (btnPressed(BTN_LEFT)) { state = DIR_FINDER_MENU; menuIndex = 0; }
  }

  // ── DELETE LOCATION ────────────────────────────────────────────────────────
  else if (state == DELETE_LOCATION) {
    drawLocationList("DELETE LOCATION");
    if (locationCount == 0) {
      if (btnPressed(BTN_LEFT)) { state = DIR_FINDER_MENU; menuIndex = 0; }
      return;
    }
    if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = locationCount - 1; }
    if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex >= locationCount) menuIndex = 0; }
    if (btnPressed(BTN_PRESS) && locationCount > 0) {
      state = DELETE_CONFIRM;
    }
    if (btnPressed(BTN_LEFT)) { state = DIR_FINDER_MENU; menuIndex = 0; }
  }

  // ── DELETE CONFIRM ─────────────────────────────────────────────────────────
  else if (state == DELETE_CONFIRM) {
    drawDeleteConfirm(locations[menuIndex].name);
    if (btnPressed(BTN_PRESS)) {
      for (int i = menuIndex; i < locationCount - 1; i++)
        locations[i] = locations[i + 1];
      locationCount--;
      saveLocations();
      if (menuIndex >= locationCount && menuIndex > 0) menuIndex--;
      state = DELETE_LOCATION;
    }
    if (btnPressed(BTN_LEFT)) { state = DELETE_LOCATION; }
  }

  // ── KEYPAD NAME ────────────────────────────────────────────────────────────
  else if (state == KEYPAD_NAME) {
    drawNameInput();
    if (btnPressed(BTN_UP))    { charIndex++; if (charIndex >= (int)sizeof(nameChars) - 1) charIndex = 0; }
    if (btnPressed(BTN_DOWN))  { charIndex--; if (charIndex < 0) charIndex = sizeof(nameChars) - 2; }
    if (btnPressed(BTN_PRESS)) {
      if (inputName.length() < 15) inputName += nameChars[charIndex];
    }
    if (btnPressed(BTN_LEFT))  {
      if (inputName.length() > 0) inputName.remove(inputName.length() - 1);
      else { state = DIR_FINDER_MENU; menuIndex = 0; }
    }
    if (btnPressed(BTN_RIGHT)) {
      // Validate: must not be empty
      if (inputName.length() == 0) {
        saveErrorMsg = "Name cannot be empty.";
        state = SAVE_ERROR;
      } else {
        // Check for duplicate name
        bool dup = false;
        for (int i = 0; i < locationCount; i++) {
          if (inputName.equalsIgnoreCase(locations[i].name)) { dup = true; break; }
        }
        if (dup) {
          saveErrorMsg = "Name already exists.";
          state = SAVE_ERROR;
        } else {
          coordInput = ""; numIndex = 0; state = INPUT_LAT;
        }
      }
    }
  }

  // ── INPUT LAT ──────────────────────────────────────────────────────────────
  else if (state == INPUT_LAT) {
    drawCoordInput("LATITUDE");
    if (btnPressed(BTN_UP))    { numIndex++; if (numIndex >= (int)sizeof(numChars) - 1) numIndex = 0; }
    if (btnPressed(BTN_DOWN))  { numIndex--; if (numIndex < 0) numIndex = sizeof(numChars) - 2; }
    if (btnPressed(BTN_PRESS)) { coordInput += numChars[numIndex]; }
    if (btnPressed(BTN_LEFT))  {
      if (coordInput.length() > 0) coordInput.remove(coordInput.length() - 1);
      else { state = KEYPAD_NAME; }
    }
    if (btnPressed(BTN_RIGHT)) {
      if (coordInput.length() == 0) {
        saveErrorMsg = "Latitude is empty.";
        state = SAVE_ERROR;
      } else {
        tempLat = coordInput.toDouble();
        coordInput = ""; numIndex = 0; state = INPUT_LON;
      }
    }
  }

  // ── INPUT LON ──────────────────────────────────────────────────────────────
  else if (state == INPUT_LON) {
    drawCoordInput("LONGITUDE");
    if (btnPressed(BTN_UP))    { numIndex++; if (numIndex >= (int)sizeof(numChars) - 1) numIndex = 0; }
    if (btnPressed(BTN_DOWN))  { numIndex--; if (numIndex < 0) numIndex = sizeof(numChars) - 2; }
    if (btnPressed(BTN_PRESS)) { coordInput += numChars[numIndex]; }
    if (btnPressed(BTN_LEFT))  {
      if (coordInput.length() > 0) coordInput.remove(coordInput.length() - 1);
      else { coordInput = ""; numIndex = 0; state = INPUT_LAT; }
    }
    if (btnPressed(BTN_RIGHT)) {
      if (coordInput.length() == 0) {
        saveErrorMsg = "Longitude is empty.";
        state = SAVE_ERROR;
      } else {
        tempLon = coordInput.toDouble();
        state = SAVE_CONFIRM;
      }
    }
  }

  // ── SAVE CONFIRM ─────────────────────────────────────────────────────────────────────────
  else if (state == SAVE_CONFIRM) {
    drawSaveConfirm();
    if (btnPressed(BTN_PRESS)) {
      if (locationCount < 10) {
        strncpy(locations[locationCount].name, inputName.c_str(), 15);
        locations[locationCount].name[15] = '\0';
        locations[locationCount].lat = tempLat;
        locations[locationCount].lon = tempLon;
        locationCount++;
        saveLocations();
      }
      state = DIR_FINDER_MENU; menuIndex = 0;
    }
    if (btnPressed(BTN_LEFT)) { coordInput = ""; numIndex = 0; state = INPUT_LON; }
  }

  // ── SAVE ERROR ───────────────────────────────────────────────────────────────────────────
  else if (state == SAVE_ERROR) {
    drawSaveError();
    if (btnPressed(BTN_PRESS) || btnPressed(BTN_LEFT)) {
      if (saveErrorMsg.startsWith("Name")) state = KEYPAD_NAME;
      else if (saveErrorMsg.startsWith("Lat")) state = INPUT_LAT;
      else state = INPUT_LON;
    }
  }

  // ── NAVIGATING ─────────────────────────────────────────────────────────────
  else if (state == NAVIGATING) {
    runNavigation();
    delay(200);
  }

  // ── COMPASS ────────────────────────────────────────────────────────────────
  else if (state == COMPASS) {
    runDigitalCompass();
    delay(200);
  }

  // ── WIFI SCAN ──────────────────────────────────────────────────────────────
  else if (state == WIFI_SCAN) {
    drawWiFiScan();
    if (btnPressed(BTN_UP))   { networkIndex--; if (networkIndex < 0) networkIndex = networkCount - 1; }
    if (btnPressed(BTN_DOWN)) { networkIndex++; if (networkIndex >= networkCount) networkIndex = 0; }
    if (btnPressed(BTN_PRESS)) {
      // Find or create slot for this SSID
      pendingNetworkIdx = -1;
      for (int _i=0; _i<savedNetworkCount; _i++)
        if (strcmp(savedNetworks[_i].ssid, scannedSSIDs[networkIndex].c_str())==0)
          { pendingNetworkIdx = _i; break; }
      if (pendingNetworkIdx == -1) {
        pendingNetworkIdx = (savedNetworkCount < MAX_SAVED_WIFI) ? savedNetworkCount : MAX_SAVED_WIFI-1;
      }
      strncpy(savedNetworks[pendingNetworkIdx].ssid, scannedSSIDs[networkIndex].c_str(), 31);
      savedNetworks[pendingNetworkIdx].ssid[31] = '\0';
      // If already saved, reconnect directly without re-entering password
      if (pendingNetworkIdx < savedNetworkCount &&
          strlen(savedNetworks[pendingNetworkIdx].password) > 0) {
        activeNetworkIdx = pendingNetworkIdx;
        connectNetworkByIndex(pendingNetworkIdx);
        state = SETTINGS_MENU; menuIndex = 0;
      } else {
        menuIndex = 0;
        state = WIFI_TYPE_SELECT;
      }
    }
    if (btnPressed(BTN_LEFT)) { state = SETTINGS_MENU; menuIndex = 0; }
    delay(150);
  }

  // ── WIFI TYPE SELECT ───────────────────────────────────────────────────────
  else if (state == WIFI_TYPE_SELECT) {
    drawWiFiTypeSelect();
    if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = 1; }
    if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex > 1) menuIndex = 0; }
    if (btnPressed(BTN_PRESS)) {
      if (menuIndex == 0) {
        // Personal — skip username
        savedNetworks[pendingNetworkIdx].enterprise = false;
        memset(savedNetworks[pendingNetworkIdx].username, 0, 32);
        inputPassword = ""; charIndex = 0; activeSet = CAPS;
        state = WIFI_SETUP_PASS;
      } else {
        // Enterprise LDAP — collect username first
        savedNetworks[pendingNetworkIdx].enterprise = true;
        inputUsername = ""; charIndex = 0; activeSet = LOWER;
        state = WIFI_SETUP_USER;
      }
    }
    if (btnPressed(BTN_LEFT)) { state = WIFI_SCAN; menuIndex = 0; }
  }

  // ── WIFI USERNAME (LDAP) ───────────────────────────────────────────────────
  else if (state == WIFI_SETUP_USER) {
    drawTextInput("LDAP Username:", inputUsername, false);

    int len = getCurrentCharsLen();
    int totalLen = (activeSet == SPECIAL) ? len + 1 : len;

    if (btnPressed(BTN_UP))   { charIndex++; if (charIndex >= totalLen) charIndex = 0; }
    if (btnPressed(BTN_DOWN)) { charIndex--; if (charIndex < 0) charIndex = totalLen - 1; }

    if (btnPressed(BTN_PRESS)) {
      if (activeSet == SPECIAL && charIndex >= len) {
        // DONE — save username, move to password
        strncpy(savedNetworks[pendingNetworkIdx].username, inputUsername.c_str(), 31);
        savedNetworks[pendingNetworkIdx].username[31] = '\0';
        inputPassword = ""; charIndex = 0; activeSet = CAPS;
        state = WIFI_SETUP_PASS;
      } else {
        inputUsername += getCurrentChars()[charIndex];
      }
    }
    if (btnPressed(BTN_LEFT)) {
      if (inputUsername.length() > 0) inputUsername.remove(inputUsername.length() - 1);
      else { activeSet = CAPS; charIndex = 0; state = WIFI_TYPE_SELECT; menuIndex = 0; }
    }
    if (btnPressed(BTN_RIGHT)) {
      switch (activeSet) {
        case CAPS:    activeSet = LOWER;   break;
        case LOWER:   activeSet = DIGITS;  break;
        case DIGITS:  activeSet = SPECIAL; break;
        case SPECIAL: activeSet = CAPS;    break;
      }
      charIndex = 0;
    }
  }

  // ── WIFI PASSWORD ──────────────────────────────────────────────────────────
  else if (state == WIFI_SETUP_PASS) {
    drawTextInput("WiFi Password:", inputPassword, true);

    int len = getCurrentCharsLen();
    int totalLen = (activeSet == SPECIAL) ? len + 1 : len;

    if (btnPressed(BTN_UP))   { charIndex++; if (charIndex >= totalLen) charIndex = 0; }
    if (btnPressed(BTN_DOWN)) { charIndex--; if (charIndex < 0) charIndex = totalLen - 1; }

    if (btnPressed(BTN_PRESS)) {
      if (activeSet == SPECIAL && charIndex >= len) {
        // DONE — save and connect
        // Save into savedNetworks slot (ssid already stored in pendingNetworkIdx slot)
        strncpy(savedNetworks[pendingNetworkIdx].password, inputPassword.c_str(), 63);
        savedNetworks[pendingNetworkIdx].password[63] = '\0';
        // Add to saved list if new
        bool found = false;
        for (int _i=0; _i<savedNetworkCount; _i++)
          if (strcmp(savedNetworks[_i].ssid, savedNetworks[pendingNetworkIdx].ssid)==0 && _i!=pendingNetworkIdx) { found=true; break; }
        if (!found && savedNetworkCount <= pendingNetworkIdx)
          savedNetworkCount = pendingNetworkIdx + 1;
        saveWiFiNetworks();
        activeNetworkIdx = pendingNetworkIdx;
        connectNetworkByIndex(pendingNetworkIdx);
        activeSet = CAPS; charIndex = 0;
        state = SETTINGS_MENU; menuIndex = 0;
      } else {
        inputPassword += getCurrentChars()[charIndex];
      }
    }
    if (btnPressed(BTN_LEFT)) {
      if (inputPassword.length() > 0) inputPassword.remove(inputPassword.length() - 1);
      else { activeSet = CAPS; charIndex = 0; state = WIFI_TYPE_SELECT; menuIndex = 0; }
    }
    if (btnPressed(BTN_RIGHT)) {
      switch (activeSet) {
        case CAPS:    activeSet = LOWER;   break;
        case LOWER:   activeSet = DIGITS;  break;
        case DIGITS:  activeSet = SPECIAL; break;
        case SPECIAL: activeSet = CAPS;    break;
      }
      charIndex = 0;
    }
  }


  // ── SPEEDOMETER ────────────────────────────────────────────────────────────
  else if (state == SPEEDOMETER) {
    runSpeedometer();
    delay(200);
  }

  // ── DEVICE NAME INPUT ──────────────────────────────────────────────────────
  else if (state == DEVICE_NAME_INPUT) {
    // Reuse drawNameInput screen
    drawNameInput();
    if (btnPressed(BTN_UP))    { charIndex++; if (charIndex >= (int)sizeof(nameChars)-1) charIndex = 0; }
    if (btnPressed(BTN_DOWN))  { charIndex--; if (charIndex < 0) charIndex = sizeof(nameChars)-2; }
    if (btnPressed(BTN_PRESS)) {
      if (inputName.length() < 15) inputName += nameChars[charIndex];
    }
    if (btnPressed(BTN_LEFT)) {
      if (inputName.length() > 0) inputName.remove(inputName.length()-1);
      else { state = SETTINGS_MENU; menuIndex = 2; }
    }
    if (btnPressed(BTN_RIGHT)) {
      if (inputName.length() > 0) {
        strncpy(deviceName, inputName.c_str(), 31);
        deviceName[31] = '\0';
        saveSettings();
        announcePresence();   // broadcast new name immediately
        state = SETTINGS_MENU; menuIndex = 2;
      }
    }
  }


  // ── CONNECT APP ────────────────────────────────────────────────────────────
  else if (state == CONNECT_APP) {
    drawConnectApp();
    if (appClientCount > 0) {
      if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = appClientCount-1; }
      if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex >= appClientCount) menuIndex = 0; }
      if (btnPressed(BTN_PRESS)) {
        // Send pair request to selected app client
        if (mqtt.connected() && menuIndex < appClientCount) {
          String cleanMac = String(appClients[menuIndex].mac);
          cleanMac.replace(":", "");
          String topic = "lodestone/request/" + cleanMac;
          char myClean[20];
          String tmp = myMacStr; tmp.replace(":", "");
          tmp.toCharArray(myClean, sizeof(myClean));
          char payload[128];
          snprintf(payload, sizeof(payload),
            "{\"name\":\"%s\",\"mac\":\"%s\",\"type\":\"hardware\"}",
            deviceName, myClean);
          mqtt.publish(topic.c_str(), payload);
          display.clearDisplay();
          display.setTextSize(1);
          display.setCursor(0, 20); display.print("Request sent to:");
          display.setCursor(0, 34); display.print(appClients[menuIndex].name);
          display.display();
          delay(1500);
        }
      }
    }
    if (btnPressed(BTN_LEFT)) { state = DEVICE_TRACKER_MENU; menuIndex = 1; }
    delay(150);
  }

  // ── MSG INBOX ───────────────────────────────────────────────────────────────
  else if (state == MSG_INBOX) {
    drawMsgInbox();
    if (btnPressed(BTN_PRESS)) {
      // Go to target selection first
      menuIndex = 0;
      msgTarget = -1;  // default broadcast
      state = MSG_TARGET_SELECT;
    }
    if (btnPressed(BTN_LEFT)) { state = DEVICE_TRACKER_MENU; menuIndex = 2; }
    delay(150);
  }

  // ── MSG TARGET SELECT ──────────────────────────────────────────────────────
  else if (state == MSG_TARGET_SELECT) {
    drawMsgTargetSelect();
    // count paired hardware targets
    int _pairedHw = 0;
    for (int i = 0; i < nearbyCount; i++) if (isNearbyDevicePaired(i)) _pairedHw++;
    int maxOpts = 1 + appClientCount + _pairedHw;  // broadcast + apps + paired hw
    if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = maxOpts-1; }
    if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex >= maxOpts) menuIndex = 0; }
    if (btnPressed(BTN_PRESS)) {
      msgTarget = menuIndex - 1;  // -1=broadcast, 0..N=client index
      composeMsgLen = 0;
      memset(composeMsg, 0, sizeof(composeMsg));
      charIndex = 0;
      state = MSG_COMPOSE;
    }
    if (btnPressed(BTN_LEFT)) { state = MSG_INBOX; }
    delay(150);
  }

  // ── MSG COMPOSE ─────────────────────────────────────────────────────────────
  else if (state == MSG_COMPOSE) {
    drawMsgCompose();
    if (btnPressed(BTN_UP))   { charIndex++; if (charIndex >= (int)sizeof(nameChars)-1) charIndex = 0; }
    if (btnPressed(BTN_DOWN)) { charIndex--; if (charIndex < 0) charIndex = sizeof(nameChars)-2; }
    if (btnPressed(BTN_PRESS)) {
      if (composeMsgLen < 50) {
        composeMsg[composeMsgLen++] = nameChars[charIndex];
        composeMsg[composeMsgLen] = '\0';
      }
    }
    if (btnPressed(BTN_LEFT)) {
      if (composeMsgLen > 0) { composeMsgLen--; composeMsg[composeMsgLen] = '\0'; }
      else { state = MSG_INBOX; }
    }
    if (btnPressed(BTN_RIGHT) && composeMsgLen > 0 && mqtt.connected()) {
      char myClean[20];
      String tmp = myMacStr; tmp.replace(":", "");
      tmp.toCharArray(myClean, sizeof(myClean));
      char payload[256];
      snprintf(payload, sizeof(payload),
        "{\"from\":\"%s\",\"mac\":\"%s\",\"msg\":\"%s\"}",
        deviceName, myClean, composeMsg);

      if (msgTarget == -1) {
        // Broadcast — send only to currently paired devices/apps
        // via each peer's personal inbox topic. No global broadcast.
        for (int _p = 0; _p < pairedMacCount; _p++) {
          String _t = "lodestone/msg/" + String(pairedMacs[_p]);
          mqtt.publish(_t.c_str(), payload);
        }
      } else if (msgTarget >= 0 && msgTarget < appClientCount) {
        // Targeted send to an app client — but only if paired
        String clientMac = String(appClients[msgTarget].mac);
        clientMac.replace(":", "");
        if (!isAlreadyPaired(clientMac)) {
          display.clearDisplay();
          display.setTextSize(1);
          display.setCursor(0, 20); display.print("Not paired with:");
          display.setCursor(0, 34); display.print(appClients[msgTarget].name);
          display.display(); delay(1500);
          state = MSG_TARGET_SELECT; return;
        }
        String topic = "lodestone/msg/" + clientMac;
        mqtt.publish(topic.c_str(), payload);
      } else {
        // Targeted send to a paired hardware Lodestone
        int hwIdx = msgTarget - appClientCount;
        int seen = 0; int realIdx = -1;
        for (int i = 0; i < nearbyCount; i++) {
          if (isNearbyDevicePaired(i)) { if (seen == hwIdx) { realIdx = i; break; } seen++; }
        }
        if (realIdx >= 0) {
          char mc[20];
          snprintf(mc, sizeof(mc), "%02X%02X%02X%02X%02X%02X",
            nearbyDevices[realIdx].mac[0],nearbyDevices[realIdx].mac[1],nearbyDevices[realIdx].mac[2],
            nearbyDevices[realIdx].mac[3],nearbyDevices[realIdx].mac[4],nearbyDevices[realIdx].mac[5]);
          String topic = "lodestone/msg/" + String(mc);
          mqtt.publish(topic.c_str(), payload);
        }
      }

      // Add to own inbox as sent
      if (inboxCount < 5) inboxCount++;
      for (int i = inboxCount-1; i > 0; i--) strncpy(inboxMsgs[i], inboxMsgs[i-1], 63);
      char sentLine[64];
      char _hwName[16] = "?";
      if (msgTarget >= appClientCount && msgTarget < appClientCount + nearbyCount) {
        int hwIdx = msgTarget - appClientCount;
        int seen = 0;
        for (int i = 0; i < nearbyCount; i++) {
          if (isNearbyDevicePaired(i)) {
            if (seen == hwIdx) { strncpy(_hwName, nearbyDevices[i].name, 15); _hwName[15]=0; break; }
            seen++;
          }
        }
      }
      const char* toName = (msgTarget == -1) ? "All paired" :
                           (msgTarget < appClientCount ? appClients[msgTarget].name : _hwName);
      snprintf(sentLine, sizeof(sentLine), "Me->%s: %s", toName, composeMsg);
      strncpy(inboxMsgs[0], sentLine, 63);
      composeMsgLen = 0; memset(composeMsg, 0, sizeof(composeMsg));
      display.clearDisplay();
      display.setTextSize(1);
      display.setCursor(10, 20); display.print("Sent to:");
      display.setCursor(10, 34); display.print(toName);
      display.display(); delay(1000);
      state = MSG_INBOX;
    }
    delay(150);
  }

  // ── PAIR REQUEST ───────────────────────────────────────────────────────────
  else if (state == PAIR_REQUEST) {
    drawPairRequest();
    if (btnPressed(BTN_PRESS)) {
      // Accept — save pairing and publish accept
      String cleanPeerMac = pendingPairMac; cleanPeerMac.replace(":", "");
      addPairedDevice(cleanPeerMac);  // persist to EEPROM
      String acceptTopic = "lodestone/accept/" + cleanPeerMac;
      char accBuf[128];
      snprintf(accBuf, sizeof(accBuf), "{\"name\":\"%s\",\"mac\":\"%s\"}", deviceName, myMacStr.c_str());
      mqtt.publish(acceptTopic.c_str(), accBuf);
      // Subscribe to shared pair topic
      // Subscribe to shared pair topic
      String myClean2 = myMacStr; myClean2.replace(":", "");
      String peerClean = pendingPairMac; peerClean.replace(":", "");
      String pairTopicStr = "lodestone/pair/" + myClean2 + "_" + peerClean;
      mqtt.subscribe(pairTopicStr.c_str());
      display.clearDisplay();
      display.setTextSize(1);
      display.setCursor(10, 24); display.print("Paired with");
      display.setCursor(10, 36); display.print(pendingPairName);
      display.display();
      delay(1500);
      state = MAIN_MENU; menuIndex = 0;
    }
    if (btnPressed(BTN_LEFT)) {
      state = MAIN_MENU; menuIndex = 0;
    }
  }

  // ── SETTINGS MENU ──────────────────────────────────────────────────────────
  else if (state == SETTINGS_MENU) {
    drawSettingsMenu();
    if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = 4; }
    if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex > 4) menuIndex = 0; }
    if (btnPressed(BTN_PRESS)) {
      if (menuIndex == 0) {           // WiFi Setup
        networkIndex = 0;
        scanNetworks();
        if (networkCount > 0) {
          state = WIFI_SCAN;
        } else {
          display.clearDisplay();
          display.setTextSize(1);
          display.setCursor(0, 16); display.print("No networks found.");
          display.setCursor(0, 30); display.print("Check WiFi antenna");
          display.setCursor(0, 44); display.print("or move closer.");
          display.display();
          delay(2000);
        }
      }
      if (menuIndex == 1) {           // Disconnect WiFi
        if (wifiConnected) {
          WiFi.disconnect(true);
          wifiConnected = false;
          display.clearDisplay();
          display.setTextSize(1);
          display.setCursor(16, 20); display.print("WiFi disconnected");
          display.display();
          delay(1500);
        }
      }
      if (menuIndex == 2) {           // Device Name
        inputName = String(deviceName);
        charIndex = 0;
        state = DEVICE_NAME_INPUT;
      }
      if (menuIndex == 3) {           // Bluetooth (placeholder)
        display.clearDisplay();
        display.setTextSize(1);
        display.setCursor(10, 20); display.print("BT: Coming soon");
        display.setCursor(10, 34); display.print("(MQTT app ready)");
        display.display();
        delay(2000);
      }
      if (menuIndex == 4) {           // Sleep time
        const uint8_t opts[] = {0,1,2,5};
        menuIndex = 0;
        for (int i=0;i<4;i++) if(opts[i]==sleepTimeoutMin) menuIndex=i;
        state = SLEEP_SET;
      }
    }
    if (btnPressed(BTN_LEFT)) { state = MAIN_MENU; menuIndex = 0; }
  }

  // ── SLEEP SET ──────────────────────────────────────────────────────────────
  else if (state == SLEEP_SET) {
    drawSleepSet();
    const uint8_t opts[] = {0, 1, 2, 5};
    if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = 4; }
    if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex > 4) menuIndex = 0; }
    if (btnPressed(BTN_PRESS)) {
      sleepTimeoutMin = opts[menuIndex];
      saveSettings();
      menuIndex = 4;
      state = SETTINGS_MENU;
    }
    if (btnPressed(BTN_LEFT)) { menuIndex = 4; state = SETTINGS_MENU; }
  }

  // ── DEVICE TRACKER ─────────────────────────────────────────────────────────
  // ── PAIR LODESTONE ─────────────────────────────
  else if (state == PAIR_LODESTONE) {
    drawPairLodestone();
    // Build list of unpaired hardware indices
    int unpIdx[MAX_DEVICES]; int unpN = 0;
    for (int i = 0; i < nearbyCount; i++) {
      if (nearbyDevices[i].isHardware && !isNearbyDevicePaired(i)) {
        if (unpN < MAX_DEVICES) unpIdx[unpN++] = i;
      }
    }
    if (unpN > 0) {
      if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = unpN - 1; }
      if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex >= unpN) menuIndex = 0; }
      if (btnPressed(BTN_PRESS) && mqtt.connected()) {
        int idx = unpIdx[menuIndex];
        char peerClean[20];
        snprintf(peerClean, sizeof(peerClean), "%02X%02X%02X%02X%02X%02X",
          nearbyDevices[idx].mac[0],nearbyDevices[idx].mac[1],nearbyDevices[idx].mac[2],
          nearbyDevices[idx].mac[3],nearbyDevices[idx].mac[4],nearbyDevices[idx].mac[5]);
        String topic = "lodestone/request/" + String(peerClean);
        char myClean[20];
        String tmp = myMacStr; tmp.replace(":", "");
        tmp.toCharArray(myClean, sizeof(myClean));
        char payload[128];
        snprintf(payload, sizeof(payload),
          "{\"name\":\"%s\",\"mac\":\"%s\",\"type\":\"hardware\"}",
          deviceName, myClean);
        mqtt.publish(topic.c_str(), payload);
        display.clearDisplay();
        display.setTextSize(1);
        display.setCursor(0, 20); display.print("Request sent to:");
        display.setCursor(0, 34); display.print(nearbyDevices[idx].name);
        display.display();
        delay(1500);
      }
    }
    if (btnPressed(BTN_LEFT)) { state = DEVICE_TRACKER_MENU; menuIndex = 1; }
    delay(150);
  }

  else if (state == DEVICE_TRACKER) {
    drawDeviceTracker();
    // Build visible-row -> nearbyDevices[] index map
    int vmap[MAX_DEVICES]; int vn = 0;
    for (int i = 0; i < nearbyCount; i++) if (isNearbyDevicePaired(i)) { if (vn<MAX_DEVICES) vmap[vn++] = i; }
    if (wifiConnected && vn > 0) {
      if (btnPressed(BTN_UP))   { menuIndex--; if (menuIndex < 0) menuIndex = vn - 1; }
      if (btnPressed(BTN_DOWN)) { menuIndex++; if (menuIndex >= vn) menuIndex = 0; }
      if (btnPressed(BTN_PRESS)) { selectedDevice = vmap[menuIndex]; state = DEVICE_TRACKING; }
      if (btnPressed(BTN_RIGHT)) { selectedDevice = vmap[menuIndex]; state = UNPAIR_CONFIRM; }
    }
    if (btnPressed(BTN_LEFT)) { state = DEVICE_TRACKER_MENU; menuIndex = 0; }
    delay(200);
  }

  // UNPAIR CONFIRM
  else if (state == UNPAIR_CONFIRM) {
    display.clearDisplay();
    display.setTextSize(1);
    display.setTextColor(WHITE);
    display.setCursor(0, 0); display.print("UNPAIR?");
    display.drawLine(0, 10, 127, 10, WHITE);
    display.setCursor(0, 18); display.print(nearbyDevices[selectedDevice].name);
    display.setCursor(0, 36); display.print("PRESS = confirm");
    display.setCursor(0, 48); display.print("LEFT  = cancel");
    display.display();
    if (btnPressed(BTN_PRESS)) {
      char mc[20];
      snprintf(mc, sizeof(mc), "%02X%02X%02X%02X%02X%02X",
        nearbyDevices[selectedDevice].mac[0],nearbyDevices[selectedDevice].mac[1],
        nearbyDevices[selectedDevice].mac[2],nearbyDevices[selectedDevice].mac[3],
        nearbyDevices[selectedDevice].mac[4],nearbyDevices[selectedDevice].mac[5]);
      String peer = String(mc);
      removePairedDevice(peer);
      String myClean = myMacStr; myClean.replace(":", "");
      mqtt.unsubscribe(("lodestone/pair/" + myClean + "_" + peer).c_str());
      mqtt.unsubscribe(("lodestone/pair/" + peer + "_" + myClean).c_str());
      char pl[96];
      snprintf(pl, sizeof(pl), "{\"mac\":\"%s\",\"name\":\"%s\"}", myClean.c_str(), deviceName);
      mqtt.publish(("lodestone/unpair/" + peer).c_str(), pl);
      display.clearDisplay();
      display.setCursor(10, 28); display.print("Unpaired.");
      display.display(); delay(1000);
      state = DEVICE_TRACKER; menuIndex = 0;
    }
    if (btnPressed(BTN_LEFT)) { state = DEVICE_TRACKER; }
    delay(150);
  }

  // ── DEVICE TRACKING ────────────────────────────────────────────────────────
  else if (state == DEVICE_TRACKING) {
    runDeviceTracking();
    delay(200);
  }
}
